v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 260 220 1060 620 {flags=graph
y1=1.6
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=5e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
sim_type=tran
autoload=1
rawfile=$netlist_dir/tb_sunrise_opamp_tran.raw
color="4 7 8 9 10"
node="vih
vil
vip_stg2
vin_stg2
vout"}
B 2 1080 220 1880 620 {flags=graph
y1=-73
y2=110
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-1
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0
node="\\" 0 \\"

\\"tt27vnomrnom;av db20()\\"

\\"ff125vmaxrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_125.raw\\"
\\"ffn40vmaxrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_n40.raw\\"
\\"ff125vminrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_125.raw\\"
\\"ffn40vminrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_n40.raw\\"

\\"ff125vmaxrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_125.raw\\"
\\"ffn40vmaxrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_n40.raw\\"
\\"ff125vminrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_125.raw\\"
\\"ffn40vminrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_n40.raw\\"

\\"fs125vmaxrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_125.raw\\"
\\"fsn40vmaxrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_n40.raw\\"
\\"fs125vminrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_125.raw\\"
\\"fsn40vminrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_n40.raw\\"

\\"fs125vmaxrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_max_125.raw\\"
\\"fsn40vmaxrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_max_n40.raw\\"
\\"fs125vminrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_125.raw\\"
\\"fsn40vminrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_n40.raw\\"

\\"sf125vmaxrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_125.raw\\"
\\"sfn40vmaxrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_n40.raw\\"
\\"sf125vminrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_125.raw\\"
\\"sfn40vminrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_n40.raw\\"

\\"sf125vmaxrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_125.raw\\"
\\"sfn40vmaxrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_n40.raw\\"
\\"sf125vminrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_125.raw\\"
\\"sfn40vminrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_n40.raw\\"

\\"ss125vmaxrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_125.raw\\"
\\"ssn40vmaxrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_n40.raw\\"
\\"ss125vminrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_125.raw\\"
\\"ssn40vminrbcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_n40.raw\\"

\\"ss125vmaxrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_125.raw\\"
\\"ssn40vmaxrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_n40.raw\\"
\\"ss125vminrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_125.raw\\"
\\"ssn40vminrwcs;av db20()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_n40.raw\\""
color="10 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18"
dataset=-1
unitx=1
logx=1
logy=0
rawfile=$netlist_dir/tb_sunrise_opamp_ac2.raw
sim_type=ac
autoload=1
x2=8
vlegend=1
hilight_wave=8}
B 2 1080 640 1880 1040 {flags=graph
y1=-180
y2=0
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-1
divx=5
subdivx=8
xlabmag=1.0
ylabmag=0.8
node="\\" -45\\"
\\" -90\\"
\\" -180\\"

\\"tt27vnomrnom;ph(av) cph()\\"

\\"ff125vmaxrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_125.raw\\"
\\"ffn40vmaxrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_n40.raw\\"
\\"ff125vminrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_125.raw\\"
\\"ffn40vminrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_n40.raw\\"

\\"ff125vmaxrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_125.raw\\"
\\"ffn40vmaxrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_n40.raw\\"
\\"ff125vminrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_125.raw\\"
\\"ffn40vminrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_n40.raw\\"

\\"fs125vmaxrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_125.raw\\"
\\"fsn40vmaxrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_n40.raw\\"
\\"fs125vminrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_125.raw\\"
\\"fsn40vminrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_n40.raw\\"

\\"fs125vmaxrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_max_125.raw\\"
\\"fsn40vmaxrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_max_n40.raw\\"
\\"fs125vminrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_125.raw\\"
\\"fsn40vminrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_n40.raw\\"

\\"sf125vmaxrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_125.raw\\"
\\"sfn40vmaxrbcs;ph(av)v%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_n40.raw\\"
\\"sf125vminrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_125.raw\\"
\\"sfn40vminrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_n40.raw\\"

\\"sf125vmaxrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_125.raw\\"
\\"sfn40vmaxrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_n40.raw\\"
\\"sf125vminrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_125.raw\\"
\\"sfn40vminrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_n40.raw\\"

\\"ss125vmaxrbcs;ph(av)v%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_125.raw\\"
\\"ssn40vmaxrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_n40.raw\\"
\\"ss125vminrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_125.raw\\"
\\"ssn40vminrbcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_n40.raw\\"

\\"ss125vmaxrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_125.raw\\"
\\"ssn40vmaxrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_n40.raw\\"
\\"ss125vminrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_125.raw\\"
\\"ssn40vminrwcs;ph(av) cph()%$netlist_dir/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_n40.raw\\""
color="11 12 16 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18"
dataset=-1
unitx=1
logx=1
logy=0
rawfile=$netlist_dir/tb_sunrise_opamp_ac2.raw
sim_type=ac
autoload=1
x2=8
hcursor1_y=-176.96331
vlegend=1}
B 2 1900 220 2700 620 {flags=graph
y1=3.3e-10
y2=7.6e-07
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=8
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=1
logy=0
sim_type=noise
autoload=1
color="4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18"
node="\\"tt27vnomrnom;onoise_spectrum\\"

\\"ff125vmaxrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_max_125.raw\\"
\\"ffn40vmaxrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_max_n40.raw\\"
\\"ff125vminrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_min_125.raw\\"
\\"ffn40vminrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_min_n40.raw\\"

\\"ff125vmaxrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_max_125.raw\\"
\\"ffn40vmaxrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_max_n40.raw\\"
\\"ff125vminrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_min_125.raw\\"
\\"ffn40vminrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_min_n40.raw\\"

\\"fs125vmaxrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_max_125.raw\\"
\\"fsn40vmaxrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_max_n40.raw\\"
\\"fs125vminrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_min_125.raw\\"
\\"fsn40vminrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_min_n40.raw\\"

\\"fs125vmaxrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_max_125.raw\\"
\\"fsn40vmaxrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_max_n40.raw\\"
\\"fs125vminrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_min_125.raw\\"
\\"fsn40vminrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_min_n40.raw\\"

\\"sf125vmaxrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_max_125.raw\\"
\\"sfn40vmaxrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_max_n40.raw\\"
\\"sf125vminrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_min_125.raw\\"
\\"sfn40vminrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_min_n40.raw\\"

\\"sf125vmaxrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_max_125.raw\\"
\\"sfn40vmaxrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_max_n40.raw\\"
\\"sf125vminrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_min_125.raw\\"
\\"sfn40vminrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_min_n40.raw\\"

\\"ss125vmaxrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_max_125.raw\\"
\\"ssn40vmaxrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_max_n40.raw\\"
\\"ss125vminrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_min_125.raw\\"
\\"ssn40vminrbcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_min_n40.raw\\"

\\"ss125vmaxrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_max_125.raw\\"
\\"ssn40vmaxrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_max_n40.raw\\"
\\"ss125vminrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_min_125.raw\\"
\\"ssn40vminrwcs;onoise_spectrum%$netlist_dir/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_min_n40.raw\\""
rawfile=$netlist_dir/tb_sunrise_opamp_noise_density.raw
vlegend=1}
B 2 1900 640 2700 1040 {flags=graph
y1=0
y2=8.3e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=8
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=1
logy=0
rawfile=$netlist_dir/tb_sunrise_opamp_noise_density.raw
sim_type=noise
autoload=1
color=4
node="\\"integrated_noise; onoise_spectrum onoise_spectrum * integ() sqrt()\\""}
B 2 260 1060 1060 1460 {flags=graph
y1=-4.1e-06
y2=1.2e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=5e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/tb_sunrise_opamp_tran.raw
sim_type=tran
autoload=1
hcursor1_y=2.6035
color=4
node=i(viout)}
B 2 1080 1060 1880 1460 {flags=graph
y1=-170
y2=91
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-1
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0
node="\\" 0 \\"

\\"IA;av db20()\\""
color="10 4"
dataset=-1
unitx=1
logx=1
logy=0
rawfile=$netlist_dir/tb_sunrise_opamp_ac2.raw
sim_type=ac
autoload=1
x2=8
}
B 2 1080 1480 1880 1880 {flags=graph
y1=-180
y2=0
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-1
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0
node="\\" -45\\"
\\" -90\\"
\\" -180\\"

\\"IA;ph(av)\\"
\\"NIA;ph(av)%$netlist_dir/tb_sunrise_opamp_ac2_nia.raw\\""
color="11 12 16 4 15"
dataset=-1
unitx=1
logx=1
logy=0
rawfile=$netlist_dir/tb_sunrise_opamp_ac2.raw
sim_type=ac
autoload=1
x2=8
hcursor1_y=-176.96331}
B 2 1900 1060 2700 1460 {flags=graph
y1=5.2e-10
y2=6.2e-07
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=10
x2=1e+08
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=1
logy=0
sim_type=noise
autoload=1
color=4
node="\\"tt27vnomrnom;onoise_spectrum\\""
rawfile=$netlist_dir/tb_sunrise_opamp_noise_density.raw}
B 2 1900 1480 2700 1880 {flags=graph
y1=0
y2=4.7e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=10
x2=1e+08
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=1
logy=0
rawfile=$netlist_dir/tb_sunrise_opamp_noise_density.raw
sim_type=noise
autoload=1
color=4
node="\\"integrated_noise; onoise_spectrum onoise_spectrum * integ() sqrt()\\""}
B 2 260 640 1060 1040 {flags=graph
y1=1.695
y2=1.715
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
sim_type=tran
autoload=1
rawfile=$netlist_dir/tb_sunrise_opamp_tran.raw
color="4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18"
node="\\"tt27vnomrnom;vout\\"

\\"ff125vmaxrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_125.raw\\"
\\"ffn40vmaxrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_n40.raw\\"
\\"ff125vminrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_125.raw\\"
\\"ffn40vminrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_n40.raw\\"

\\"ff125vmaxrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_125.raw\\"
\\"ffn40vmaxrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_n40.raw\\"
\\"ff125vminrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_125.raw\\"
\\"ffn40vminrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_n40.raw\\"

\\"fs125vmaxrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_125.raw\\"
\\"fsn40vmaxrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_n40.raw\\"
\\"fs125vminrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_125.raw\\"
\\"fsn40vminrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_n40.raw\\"

\\"fs125vmaxrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_125.raw\\"
\\"fsn40vmaxrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_n40.raw\\"
\\"fs125vminrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_125.raw\\"
\\"fsn40vminrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_n40.raw\\"

\\"sf125vmaxrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_125.raw\\"
\\"sfn40vmaxrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_n40.raw\\"
\\"sf125vminrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_125.raw\\"
\\"sfn40vminrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_n40.raw\\"

\\"sf125vmaxrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_125.raw\\"
\\"sfn40vmaxrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_n40.raw\\"
\\"sf125vminrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_125.raw\\"
\\"sfn40vminrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_n40.raw\\"

\\"ss125vmaxrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_125.raw\\"
\\"ssn40vmaxrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_n40.raw\\"
\\"ss125vminrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_125.raw\\"
\\"ssn40vminrbcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_n40.raw\\"

\\"ss125vmaxrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_125.raw\\"
\\"ssn40vmaxrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_n40.raw\\"
\\"ss125vminrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_125.raw\\"
\\"ssn40vminrwcs;vout%$netlist_dir/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_n40.raw\\""
vlegend=1}
T {TRANSIENT RESPONSE} 540 130 0 0 0.4 0.4 {}
T {STB ANALYSIS} 1380 130 0 0 0.4 0.4 {}
T {AC NOISE} 2040 130 0 0 0.4 0.4 {}
T {5u} -3290 1380 0 0 0.4 0.4 {}
T {5u} -3000 1380 0 0 0.4 0.4 {}
T {PU} -2430 1380 0 0 0.4 0.4 {}
T {PDPUPD} -2540 1380 0 0 0.4 0.4 {}
N -760 420 -760 440 {
lab=GND}
N -760 320 -760 360 {
lab=vssa}
N -560 420 -560 460 {
lab=vssa}
N -560 330 -560 370 {
lab=vdda_hv}
N -460 420 -460 460 {
lab=vssa}
N -460 330 -460 370 {
lab=vnbias}
N -360 420 -360 460 {
lab=vssa}
N -360 330 -360 370 {
lab=vncasc}
N -260 420 -260 460 {
lab=vssa}
N -260 330 -260 370 {
lab=vpcasc}
N -160 420 -160 460 {
lab=vssa}
N -160 320 -160 360 {
lab=vdda_lv}
N 100 960 100 1000 {lab=vout}
N 100 1060 100 1100 {
lab=vssa}
N -800 1320 -800 1360 {
lab=vssa}
N -800 1200 -700 1200 {lab=vil}
N -800 700 -700 700 {lab=vih}
N -800 1040 -800 1200 {lab=vil}
N -660 420 -660 460 {
lab=vssa}
N -660 330 -660 370 {
lab=vss_pcb}
N -800 1200 -800 1260 {lab=vil}
N -800 860 -800 980 {lab=#net1}
N -800 700 -800 800 {lab=vih}
N -1640 1120 -1600 1120 {
lab=vssa}
N -1360 1320 -1360 1360 {
lab=vssa}
N -1360 1160 -1360 1260 {lab=#net2}
N -1240 1320 -1240 1360 {
lab=vssa}
N -1240 1160 -1240 1260 {lab=#net3}
N -1360 1360 -1240 1360 {lab=vssa}
N -3320 1260 -3280 1260 {lab=vssa}
N -3280 1290 -3280 1360 {lab=vssa}
N -3280 1160 -3280 1230 {lab=#net4}
N -2980 1260 -2940 1260 {lab=vssa}
N -2980 1290 -2980 1360 {lab=vssa}
N -3160 1260 -3020 1260 {lab=#net4}
N -3280 1160 -3160 1160 {lab=#net4}
N -3160 1160 -3160 1260 {lab=#net4}
N -3240 1260 -3160 1260 {lab=#net4}
N -3020 700 -2980 700 {lab=vdda_hv}
N -3020 520 -2980 520 {lab=vdda_hv}
N -2980 420 -2980 490 {lab=vdda_hv}
N -2980 550 -2980 670 {lab=vd_pbias_bias_lhs}
N -2980 960 -2980 1230 {lab=vpcasc_in}
N -2980 780 -2980 840 {lab=vpbias_in}
N -2980 780 -2860 780 {lab=vpbias_in}
N -2980 730 -2980 780 {lab=vpbias_in}
N -2940 520 -2860 520 {lab=vpbias_in}
N -2980 960 -2820 960 {lab=vpcasc_in}
N -2980 900 -2980 960 {lab=vpcasc_in}
N -2940 700 -2820 700 {lab=vpcasc_in}
N -2620 700 -2580 700 {lab=vdda_hv}
N -2620 520 -2580 520 {lab=vdda_hv}
N -2620 420 -2620 490 {lab=vdda_hv}
N -2620 550 -2620 670 {lab=vd_pbias_bias_rhs1}
N -2860 520 -2660 520 {lab=vpbias_in}
N -2820 700 -2660 700 {lab=vpcasc_in}
N -2980 420 -2620 420 {lab=vdda_hv}
N -3280 1360 -2980 1360 {lab=vssa}
N -2860 520 -2860 780 {lab=vpbias_in}
N -2820 700 -2820 960 {lab=vpcasc_in}
N -3280 420 -2980 420 {lab=vdda_hv}
N -3280 420 -3280 750 {lab=vdda_hv}
N -3280 810 -3280 1160 {lab=#net4}
N -2620 730 -2620 1080 {lab=#net5}
N -2260 1320 -2260 1360 {lab=vssa}
N -2600 1240 -2360 1240 {lab=int_bias}
N -2600 1240 -2600 1260 {lab=int_bias}
N -2600 1320 -2600 1360 {lab=vssa}
N -2420 1360 -2260 1360 {
lab=vssa}
N -2140 1220 -2040 1220 {lab=int_bias_int}
N -2140 1240 -2040 1240 {lab=int_bias_intb}
N -2140 1260 -2040 1260 {lab=ext_bias_int}
N -2140 1280 -2040 1280 {lab=ext_bias_intb}
N -1720 1040 -1600 1040 {lab=int_bias_int_hv}
N -1760 1060 -1600 1060 {lab=int_bias_intb_hv}
N -1940 600 -1940 660 {lab=vdda_hv}
N -1980 600 -1940 600 {lab=vdda_hv}
N -2260 1360 -1360 1360 {
lab=vssa}
N -1640 880 -1640 1000 {lab=ext_bias_int_hv}
N -1680 1020 -1600 1020 {lab=ext_bias_intb_hv}
N -1680 880 -1680 1020 {lab=ext_bias_intb_hv}
N -1640 1000 -1600 1000 {lab=ext_bias_int_hv}
N -1760 880 -1760 1060 {lab=int_bias_intb_hv}
N -1720 880 -1720 1040 {lab=int_bias_int_hv}
N -1160 1020 -1120 1020 {
lab=pdb_int_hv}
N -1400 600 -1400 960 {lab=vdda_hv}
N -1940 780 -1860 780 {lab=#net6}
N -1940 720 -1940 780 {lab=#net6}
N -1940 890 -1860 890 {lab=#net7}
N -1940 840 -1900 840 {
lab=vssa}
N -1840 740 -1840 780 {
lab=vdda_hv}
N -1800 840 -1640 840 {lab=ext_bias_int_hv}
N -2620 1080 -2210 1080 {lab=#net5}
N -2100 1060 -2060 1060 {
lab=vdda_hv}
N -1940 890 -1940 940 {lab=#net7}
N -1940 1000 -1940 1080 {lab=#net8}
N -2100 1080 -2070 1080 {lab=#net9}
N -2010 1080 -1940 1080 {lab=#net8}
N -1940 1080 -1880 1080 {lab=#net8}
N -1820 1080 -1600 1080 {lab=ndio}
N -2200 1120 -2160 1120 {lab=vssa}
N -2140 1200 -2040 1200 {lab=pdb_int}
N -2140 1180 -2040 1180 {lab=pd_int}
N -2180 700 -2180 860 {lab=int_bias_int_hv}
N -2140 760 -2140 860 {lab=pd_int_hv}
N -2160 980 -2160 1020 {lab=#net10}
N -1160 1000 -1140 1000 {
lab=pd_int_hv}
N -1140 880 -1140 1000 {lab=pd_int_hv}
N -1120 880 -1120 1020 {lab=pdb_int_hv}
N -2420 1340 -2420 1360 {lab=vssa}
N -2500 1360 -2420 1360 {
lab=vssa}
N -2500 1320 -2500 1360 {lab=vssa}
N -2600 1360 -2500 1360 {
lab=vssa}
N -1940 600 -1400 600 {lab=vdda_hv}
N -2980 1360 -2600 1360 {lab=vssa}
N -2340 1140 -2260 1140 {lab=vdda_lv}
N -2420 160 -2340 160 {lab=vssa}
N -2300 170 -2300 260 {lab=vssa}
N -2300 -60 -2300 110 {lab=int_bias_int_hv}
N -2500 120 -2340 120 {lab=int_bias_int}
N -2080 160 -2000 160 {lab=vssa}
N -1960 170 -1960 260 {lab=vssa}
N -1960 -60 -1960 110 {lab=int_bias_intb_hv}
N -2160 120 -2000 120 {lab=int_bias_intb}
N -1720 160 -1640 160 {lab=vssa}
N -1600 170 -1600 260 {lab=vssa}
N -1600 -60 -1600 110 {lab=ext_bias_int_hv}
N -1800 120 -1640 120 {lab=ext_bias_int}
N -1380 160 -1300 160 {lab=vssa}
N -1260 170 -1260 260 {lab=vssa}
N -1260 -60 -1260 110 {lab=ext_bias_intb_hv}
N -1460 120 -1300 120 {lab=ext_bias_intb}
N -3160 160 -3080 160 {lab=vssa}
N -3040 170 -3040 260 {lab=vssa}
N -3040 -60 -3040 110 {lab=pdb_int_hv}
N -3240 120 -3080 120 {lab=pdb_int}
N -2820 160 -2740 160 {lab=vssa}
N -2700 170 -2700 260 {lab=vssa}
N -2700 -60 -2700 110 {lab=pd_int_hv}
N -2900 120 -2740 120 {lab=pd_int}
N -1480 1240 -1480 1340 {lab=ibias_in_5u}
N -1480 1160 -1480 1180 {lab=#net11}
N -2420 1260 -2360 1260 {lab=pdb}
N -2420 1260 -2420 1280 {lab=pdb}
N -640 860 -540 860 {lab=ibias_in_5u}
N -610 940 -540 940 {lab=pd_int_hv}
N -610 960 -540 960 {lab=pdb_int_hv}
N -120 900 40 900 {lab=vss_pcb}
N -340 780 -300 780 {
lab=vdda_hv}
N -300 780 -300 820 {lab=vdda_hv}
N -300 1100 -300 1140 {
lab=vssa}
N -120 1020 -100 1020 {lab=#net12}
N -100 1020 -100 1100 {lab=#net12}
N -100 1100 -40 1100 {lab=#net12}
N -700 900 -540 900 {lab=vih}
N -700 700 -700 900 {lab=vih}
N -700 1020 -540 1020 {lab=vil}
N -700 1020 -700 1200 {lab=vil}
N -40 960 100 960 {lab=vout}
N -40 960 -40 1000 {lab=vout}
N -120 960 -40 960 {lab=vout}
C {devices/vsource.sym} -760 390 0 0 {name=Vvssa value=0
format="@name @pinlist @value"}
C {devices/gnd.sym} -760 440 0 0 {name=l1 lab=GND}
C {devices/lab_wire.sym} -760 340 3 1 {name=p6 sig_type=std_logic lab=vssa

}
C {devices/code.sym} -60 390 0 0 {name=STIM_FILE only_toplevel=false value="** opencircuitdesign pdks install
.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerMOSlv.lib mos_tt
.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerMOShv.lib mos_tt
.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerRES.lib res_typ
* SG13G2 STD CELLS
*.include /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_stdcell/spice/sg13g2_stdcell.spice
* SG13CMOS5L STD CELLS
.include /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13cmos5l/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice


* Parameters
.param xvdda_hv = 3.3
.csparam xvdda_hv_var = 'xvdda_hv'
.param xvdda_lv = 1.5
.csparam xvdda_lv_var = 'xvdda_lv'
.param cor_id = 0
.param dec_code_var = 1
.csparam xdec_code_var = 'dec_code_var'
.csparam cor_id_var = 'cor_id'
.param xvdda = 3.3
.param xvcm = 3.3/2
.param xvocm = 3.3/2
.param xvnbias = 760m
.param xvncasc = 1.184
.param xvpcasc = 2.035
.param xnoise_on = 1
.param xvinn = 10m
.param xR1var = 100k
.param xR2var = 50k
.param xRz = 2273
.param xint_bias_en = 0
* active lo => 0 = pd
.param xpdb = 1
.param xtsim = 5u
.csparam xtsim_var = 'xtsim'
.param xAv = 5
.csparam xAv_var = 'xAv'
.param xstep_en = 1 
.param xibias = 5u
.param xvload = 0.7
.param xCl = 25p
.param xCc = 80p
.param xCz = 3.2p*0
.param xstep = 10m
.param xtstep = 10n
.csparam xtstep_var = 'xtstep'
.param xtrf = 20p
.param xvos = 0m
.param xgmdp = 1m
.param xAv0_dB = 60
.param xGBW = 1Meg

.temp 27

* vlogA instantiation
.model OTA_vcvs OTA_vcvs
.model dec2bin_10b dec2bin_10b
.model ideal_sw ideal_sw
  
.include tb_sunrise_bias_stg2_top_STEP_STB_NOISE.save
  
.save all
  
.control

pre_osdi OTA_vcvs.osdi
pre_osdi dec2bin_10b.osdi
pre_osdi ideal_sw.osdi

set xTj = ( 27 )
let xTj_var  = $xTj
set temp = $xTj 
   
** 1. DCOP ANALYSIS ** 
  
  op 
  remzerovec
  set filetype=binary
  ** first write deletes existing file
  write tb_sunrise_opamp_dcop.raw
 
** 2. TRAN ANALYSIS ** 

  remzerovec
  *set appendwrite
  tran $&xtstep_var $&xtsim_var
  write tb_sunrise_opamp_tran.raw
 *unset appendwrite 
 
** 3. STB ANALYSIS ** 

  alter i.xstb.Ii acmag=0 
  alter v.xstb.Vi acmag=1 
    
  ac dec 10 0.1 100G
  
  remzerovec 
  write tb_sunrise_opamp_ac1.raw
  
  alter i.xstb.Ii acmag=1 
  alter v.xstb.Vi acmag=0 
  
  ac dec 10 0.1 100G  
  
  * use this line if you want the phase response to start at 180deg 
  *let av = \{1/(1-1/(2*(ac1.i(v.xstb.Vi)*ac2.v(xstb.x)-ac1.v(xstb.x)*ac2.i(v.xstb.Vi))+ac1.v(xstb.x)+ac2.i(v.xstb.Vi)))\}

  * use this line if you want the phase response to start at 0deg (more conventional and directly corresponds to Franks derivation)
  let av = \{1/(1/(2*(ac1.i(v.xstb.Vi)*ac2.v(xstb.x)-ac1.v(xstb.x)*ac2.i(v.xstb.Vi))+ac1.v(xstb.x)+ac2.i(v.xstb.Vi))-1)\}
  
  remzerovec
  write tb_sunrise_opamp_ac2.raw

  ** 4. STB MEASURES **
  
  *let n45_rads = -45*(pi/180) 
  *meas AC Av_0 FIND vdb(av) AT=1
  *echo --
  *meas AC BW WHEN vp(av)=n45_rads CROSS=1
  echo --
  *meas AC Av_BW FIND vdb(av) WHEN vp(av)=n45_rads CROSS=1
  *echo --
  *meas AC ULGF WHEN vdb(av)=0
  *echo --
  *meas AC ULGF_phi_rads FIND vp(av) WHEN vdb(av)=0 CROSS=1
  *let ULGF_phi_deg = ULGF_phi_rads*(180/pi)
  *print ULGF_phi_deg
  *let PM = 180+ULGF_phi_deg
  *print PM
  *echo --
  * putting in -170 since this is a 2nd-order system so doesnt ever achieve -180
  *let n180_rads = -170*(pi/180)
  *meas AC GM FIND vdb(av) WHEN vp(av)=n180_rads CROSS=1
  
  ** 4. STB MEASURES **

  * I am using octave to summarise all ac_measures files into a csv file which is then read by loffice. loffice (mostly!) rounds to 3 decimal
  * places which I can't seem to change. Therefore, ngspice needs to output to 3 decimal places in order for the user to be able to
  * find a measurement, shown in the loffice csv summary, in the original raw files (to determine corner run). If the numbers are
  * > 10 you need csnumprec = 5 (5 digits means 10 and 3 decimal places). If the numbers are < 10 set csmnumprec = 4 and if numbers
  * are > 100, set csmnumprec = 6. This is why before I write the measure to the output txt file I check if it is < 10 / >=10 / >= 100 
  * and set csmnumprec accordingly

  * 4.0 Global parameters:   
  echo cor_id = \\"$&cor_id_var\\"
  echo \\"$&cor_id_var\\" > ac_measures.txt
  echo --
  echo temp = \\"$&xTj_var\\"
  echo \\"$&xTj_var\\" >> ac_measures.txt
  echo --  
  echo vdda_hv = \\"$&xvdda_hv_var\\"
  echo \\"$&xvdda_hv_var\\" >> ac_measures.txt
  echo --
  echo vdda_lv = \\"$&xvdda_lv_var\\"
  echo \\"$&xvdda_lv_var\\" >> ac_measures.txt
  echo -- 
  
  * 4.1 DC gain (Av_0):  
  meas AC Av_0 FIND vdb(av) AT=1
  echo \\"$&Av_0\\" >> ac_measures.txt
  echo -- 
  
  * 4.2 Bandwidth (BW):
  let n45_rads = -45*(pi/180) 
  meas AC BW WHEN vp(av)=n45_rads CROSS=1
  let BW_kHz = BW/1e3
  echo \\"$&BW_kHz\\" >> ac_measures.txt
  echo --
  
  * 4.3 Av at BW (Av_BW):
  *I am leaving this in for infomation but typically dont use it
  meas AC Av_BW FIND vdb(av) WHEN vp(av)=n45_rads CROSS=1
  *echo \\"$&Av_BW\\" >> ac_measures.txt
  echo --
  
  * 4.4 Unity loop gain frequency (ULGF):
  meas AC ULGF WHEN vdb(av)=0
  let ULGF_MHz = ULGF/1e6
  echo \\"$&ULGF_MHz\\" >> ac_measures.txt
  echo -- 
  
  * 4.5 Phase margin (PM):
  meas AC ULGF_phi_rads FIND vp(av) WHEN vdb(av)=0 CROSS=1
  let ULGF_phi_deg = ULGF_phi_rads*(180/pi)
  let PM = 180+ULGF_phi_deg
  print PM
  echo \\"$&PM\\" >> ac_measures.txt
  echo --
  
  * 4.6 Gain margin (GM):
  * putting in -179 since a purely 2nd-order system so doesnt ever achieve -180
  * will prob revisit this later and change to 180
  let n180_rads = -165*(pi/180)
  meas AC GM FIND vdb(av) WHEN vp(av)=n180_rads CROSS=1
  * Note: The no of significant digits increases by 1 to include the - sign
  echo \\"$&GM\\" >> ac_measures.txt
  echo --
    
  ** 5. AC NOISE ANALYSIS **   
  
  * 5.0 Global parameters:   
  echo cor_id = \\"$&cor_id_var\\"
  echo \\"$&cor_id_var\\" > noise_ipr_1k.txt 
  echo --
  echo temp = \\"$&xTj_var\\"
  echo \\"$&xTj_var\\" >> noise_ipr_1k.txt 
  echo --  
  echo vdda_hv = \\"$&xvdda_hv_var\\"
  echo \\"$&xvdda_hv_var\\" >> noise_ipr_1k.txt 
  echo --
  echo vdda_lv = \\"$&xvdda_lv_var\\"
  echo \\"$&xvdda_lv_var\\" >> noise_ipr_1k.txt 
  echo -- 

  let xfmax = 100Meg

  noise v(vout) Vvdda dec 10 10 100Meg 1
  print v(onoise_total)
  setplot noise2
  set filetype=binary
  remzerovec
  write tb_sunrise_opamp_noise_density.raw
  let vnoise_op_int = sqrt(integ(onoise_spectrum*onoise_spectrum))
  
  let freq_density1 = 1k
  let freq_density2 = 10k
  let freq_density3 = 100k
  
  let nn = 0
  while frequency[nn] < $&freq_density1
  let nn = nn + 1
  end
  * define vectors of frequncies and values just above and below
  * selected frequeny
  let fnn = frequency[nn]
  let nn1 = nn + 1
  let fnn1 = frequency[nn1]
  let snn = onoise_spectrum[nn]
  let snn1 = onoise_spectrum[nn1]
  *print vector values
  echo -- 
  echo nn = \\"$&nn\\"  freq_density1 = \\"$&fnn\\"  noise_density1 = \\"$&snn\\"
  echo nn1 = \\"$&nn1\\"  freq_density1+ = \\"$&fnn1\\"  noise_density1+ = \\"$&snn1\\"
  *linear interpolation for exact frequency
  let newsnn = snn1 + (snn - snn1)/(fnn - fnn1)*($&freq_density1 - fnn1)
  echo  freq_density1 = \\"$&freq_density1\\"  noise_density1_interp = \\"$&newsnn\\"
  *echo \\"$&newsnn\\" > nmos_noise_opr_1k.txt
  let newpnn = $&newsnn*$&newsnn
  echo  freq_density1 = \\"$&freq_density1\\"  noise_density1_power_opr = \\"$&newpnn\\" 
  let newpnn_ipr = $&newpnn/(xAv_var*xAv_var)
  echo gain = \\"$&xAv_var\\"
  echo  freq_density1 = \\"$&freq_density1\\"  noise_density1_power_ipr = \\"$&newpnn_ipr\\" 
  let newsnn_ipr = sqrt($&newpnn_ipr)
  echo  freq_density1 = \\"$&freq_density1\\"  noise_density1_voltage_ipr = \\"$&newsnn_ipr\\"  
  echo \\"$&newsnn_ipr\\" >> noise_ipr_1k.txt 
  echo --  
  
  let nn = 0
  while frequency[nn] < $&freq_density2
  let nn = nn + 1
  end
  * define vectors of frequncies and values just above and below
  * selected frequeny
  let fnn = frequency[nn]
  let nn1 = nn + 1
  let fnn1 = frequency[nn1]
  let snn = onoise_spectrum[nn]
  let snn1 = onoise_spectrum[nn1]
  *print vector values
  echo -- 
  echo nn = \\"$&nn\\"  freq_density2 = \\"$&fnn\\"  noise_density2 = \\"$&snn\\"
  echo nn1 = \\"$&nn1\\"  freq_density2+ = \\"$&fnn1\\"  noise_density2+ = \\"$&snn1\\"
  *linear interpolation for exact frequency
  let newsnn = snn1 + (snn - snn1)/(fnn - fnn1)*($&freq_density2 - fnn1)
  echo  freq_density2 = \\"$&freq_density2\\"  noise_density2_voltage_opr = \\"$&newsnn\\"
  *echo \\"$&newsnn\\" > nmos_noise_opr_10k.txt
  echo --  
  
  let nn = 0
  while frequency[nn] < $&freq_density3
  let nn = nn + 1
  end
  * define vectors of frequncies and values just above and below
  * selected frequeny
  let fnn = frequency[nn]
  let nn1 = nn + 1
  let fnn1 = frequency[nn1]
  let snn = onoise_spectrum[nn]
  let snn1 = onoise_spectrum[nn1]
  *print vector values
  echo -- 
  echo nn = \\"$&nn\\"  freq_density3 = \\"$&fnn\\"  noise_density3 = \\"$&snn\\"
  echo nn1 = \\"$&nn1\\"  freq_density3+ = \\"$&fnn1\\"  noise_density3+ = \\"$&snn1\\"
  *linear interpolation for exact frequency
  let newsnn = snn1 + (snn - snn1)/(fnn - fnn1)*($&freq_density3 - fnn1)
  echo  freq_density3 = \\"$&freq_density3\\"  noise_density1_interp = \\"$&newsnn\\"
  *echo \\"$&newsnn\\" > nmos_noise_opr_100k.txt
  echo --  

  setplot noise3
  set filetype=ascii
  remzerovec
  write tb_sunrise_opamp_integrated_noise.raw

  setplot
*quit 0
.endc


"}
C {launcher.sym} 580 180 0 0 {name=h1
descr="load_TRAN_waveforms" 
tclcommand="xschem raw_read $netlist_dir/tb_sunrise_opamp_tran.raw tran"


}
C {launcher.sym} 1360 180 0 0 {name=h3
descr="load_STB_waveforms" 
tclcommand="xschem raw_read $netlist_dir/tb_sunrise_opamp_ac2.raw ac"


}
C {devices/vsource.sym} -560 390 0 0 {name=Vvdda_hv value="xvdda_hv"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -560 440 1 1 {name=p10 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -560 350 1 0 {name=p11 sig_type=std_logic lab=vdda_hv

}
C {devices/vsource.sym} -460 390 0 0 {name=Vnbias value="xvnbias"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -460 440 1 1 {name=p12 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -460 350 1 0 {name=p13 sig_type=std_logic lab=vnbias

}
C {devices/vsource.sym} -360 390 0 0 {name=Vncasc value="xvncasc"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -360 440 1 1 {name=Vncasc1 sig_type=std_logic lab=vssa

value="xvncasc"}
C {devices/vsource.sym} -260 390 0 0 {name=Vpcasc value="xvpcasc"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -260 440 1 1 {name=Vpcasc1 sig_type=std_logic lab=vssa

value="xvpcasc"}
C {devices/lab_wire.sym} -360 350 1 0 {name=p14 sig_type=std_logic lab=vncasc

}
C {devices/lab_wire.sym} -260 350 1 0 {name=p15 sig_type=std_logic lab=vpcasc

}
C {devices/vsource.sym} -160 390 0 0 {name=Vvdda value="xvdda_lv ac 0"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -160 440 1 1 {name=p17 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -160 340 1 0 {name=p18 sig_type=std_logic lab=vdda_lv

}
C {devices/launcher.sym} -740 240 0 0 {name=h2
descr=load_DCOP
tclcommand="xschem annotate_op $\{netlist_dir\}/tb_sunrise_opamp_dcop.raw"
}
C {devices/launcher.sym} -740 -60 0 0 {# Temp corner sweep for Tmin = -40C, Tmax = 125C, Trt = 27C
# Assumes stim file has set temp to 27C
name=h4
descr="Temp corner group (step/stb)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_stg2_STEP_STB_NOISE.spice
xschem netlist
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# set T = 125C
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
exec sed -i \{s/set xTj = ( 27 )/set xTj = ( 125 )/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran.raw/tb_sunrise_opamp_tran_Tmax.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1.raw/tb_sunrise_opamp_ac1_Tmax.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2.raw/tb_sunrise_opamp_ac2_Tmax.raw/\} $spicefile
exec sed -i \{s/ac_measures.txt/ac_measures_Tmax.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# set T = -40C
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
exec sed -i \{s/set xTj = ( 125 )/set xTj = ( -40 )/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_Tmax.raw/tb_sunrise_opamp_tran_Tmin.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_Tmax.raw/tb_sunrise_opamp_ac1_Tmin.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_Tmax.raw/tb_sunrise_opamp_ac2_Tmin.raw/\} $spicefile
exec sed -i \{s/ac_measures_Tmax.txt/ac_measures_Tmin.txt/\} $spicefile
simulate
"
}
C {devices/launcher.sym} -740 -140 0 0 {# Process corner sweep for tt, ff, ss, sf, fs
# Assumes stim file has set corner to tt
name=h5
descr="Process corner group (step/stb)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_stg2_STEP_STB_NOISE.spice
xschem netlist
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/tt/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_tt/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_tt/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran.raw/tb_sunrise_opamp_tran_ff.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1.raw/tb_sunrise_opamp_ac1_ff.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2.raw/tb_sunrise_opamp_ac2_ff.raw/\} $spicefile
exec sed -i \{s/ac_measures.txt/ac_measures_ff.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff.raw/tb_sunrise_opamp_tran_ss.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff.raw/tb_sunrise_opamp_ac1_ss.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff.raw/tb_sunrise_opamp_ac2_ss.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff.txt/ac_measures_ss.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/2/3/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss.raw/tb_sunrise_opamp_tran_sf.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss.raw/tb_sunrise_opamp_ac1_sf.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss.raw/tb_sunrise_opamp_ac2_sf.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss.txt/ac_measures_sf.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/3/4/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf.raw/tb_sunrise_opamp_tran_fs.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf.raw/tb_sunrise_opamp_ac1_fs.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf.raw/tb_sunrise_opamp_ac2_fs.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf.txt/ac_measures_fs.txt/\} $spicefile
simulate
"
}
C {devices/launcher.sym} -740 -100 0 0 {# Supply voltage corner sweep for vdda +/-10%
# vdda_hv_typ = 3.3, vdda_hv_p10 = 3.63, vdda_hv_n10 = 2.97
# vdda_lv_typ = 1.5, vdda_lv_p10 = 1.65, vdda_lv_n10 = 1.35
# Assumes stim file has set vdda_hv = 3.3 / vdda_lv = 1.5
name=h7
descr="Voltage corner group (step/stb)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_stg2_STEP_STB_NOISE.spice
xschem netlist
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# set vdda = vdda_min
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
exec sed -i \{/^\\.param xvdda_hv/s/3.3/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.5/1.425/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran.raw/tb_sunrise_opamp_tran_vdda_min.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1.raw/tb_sunrise_opamp_ac1_vdda_min.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2.raw/tb_sunrise_opamp_ac2_vdda_min.raw/\} $spicefile
exec sed -i \{s/ac_measures.txt/ac_measures_vdda_min.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# set vdda = vdda_max
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_vdda_min.raw/tb_sunrise_opamp_tran_vdda_max.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_vdda_min.raw/tb_sunrise_opamp_ac1_vdda_max.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_vdda_min.raw/tb_sunrise_opamp_ac2_vdda_max.raw/\} $spicefile
exec sed -i \{s/ac_measures_vdda_min.txt/ac_measures_vdda_max.txt/\} $spicefile
simulate
"
}
C {devices/launcher.sym} -740 -20 0 0 {# Process corner sweep for tt, ff, ss, sf, fs
# Assumes stim file has set corner to tt
name=h9
descr="Process / Temp corner group (step/stb)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_stg2_STEP_STB_NOISE.spice
xschem netlist
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
################## change to n40 corner ################################
exec sed -i \{s/set xTj = ( 27 )/set xTj = ( -40 )/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/tt/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_tt/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_tt/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran.raw/tb_sunrise_opamp_tran_ff_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1.raw/tb_sunrise_opamp_ac1_ff_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2.raw/tb_sunrise_opamp_ac2_ff_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures.txt/ac_measures_ff_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_n40.raw/tb_sunrise_opamp_tran_ss_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_n40.raw/tb_sunrise_opamp_ac1_ss_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_n40.raw/tb_sunrise_opamp_ac2_ss_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_n40.txt/ac_measures_ss_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/2/3/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_n40.raw/tb_sunrise_opamp_tran_sf_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_n40.raw/tb_sunrise_opamp_ac1_sf_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_n40.raw/tb_sunrise_opamp_ac2_sf_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_n40.txt/ac_measures_sf_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/3/4/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_n40.raw/tb_sunrise_opamp_tran_fs_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_n40.raw/tb_sunrise_opamp_ac1_fs_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_n40.raw/tb_sunrise_opamp_ac2_fs_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_n40.txt/ac_measures_fs_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
################## change to 125 corner ################################
exec sed -i \{s/set xTj = ( -40 )/set xTj = ( 125 )/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/4/5/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_n40.raw/tb_sunrise_opamp_tran_ff_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_n40.raw/tb_sunrise_opamp_ac1_ff_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_n40.raw/tb_sunrise_opamp_ac2_ff_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_n40.txt/ac_measures_ff_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/5/6/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_125.raw/tb_sunrise_opamp_tran_ss_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_125.raw/tb_sunrise_opamp_ac1_ss_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_125.raw/tb_sunrise_opamp_ac2_ss_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_125.txt/ac_measures_ss_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/6/7/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_125.raw/tb_sunrise_opamp_tran_sf_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_125.raw/tb_sunrise_opamp_ac1_sf_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_125.raw/tb_sunrise_opamp_ac2_sf_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_125.txt/ac_measures_sf_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/7/8/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_125.raw/tb_sunrise_opamp_tran_fs_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_125.raw/tb_sunrise_opamp_ac1_fs_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_125.raw/tb_sunrise_opamp_ac2_fs_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_125.txt/ac_measures_fs_125.txt/\} $spicefile
simulate
"










}
C {devices/launcher.sym} -740 20 0 0 {# Process corner sweep for tt, ff, ss, sf, fs
# Assumes stim file has set corner to tt
name=h10
descr="Process / Voltage corner group (step/stb)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_stg2_STEP_STB_NOISE.spice
xschem netlist
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.3/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.5/1.425/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/tt/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_tt/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_tt/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran.raw/tb_sunrise_opamp_tran_ff_vdda_min.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1.raw/tb_sunrise_opamp_ac1_ff_vdda_min.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2.raw/tb_sunrise_opamp_ac2_ff_vdda_min.raw/\} $spicefile
exec sed -i \{s/ac_measures.txt/ac_measures_ff_vdda_min.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_vdda_min.raw/tb_sunrise_opamp_tran_ss_vdda_min.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_vdda_min.raw/tb_sunrise_opamp_ac1_ss_vdda_min.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_vdda_min.raw/tb_sunrise_opamp_ac2_ss_vdda_min.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_vdda_min.txt/ac_measures_ss_vdda_min.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/2/3/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_vdda_min.raw/tb_sunrise_opamp_tran_sf_vdda_min.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_vdda_min.raw/tb_sunrise_opamp_ac1_sf_vdda_min.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_vdda_min.raw/tb_sunrise_opamp_ac2_sf_vdda_min.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_vdda_min.txt/ac_measures_sf_vdda_min.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/3/4/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_vdda_min.raw/tb_sunrise_opamp_tran_fs_vdda_min.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_vdda_min.raw/tb_sunrise_opamp_ac1_fs_vdda_min.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_vdda_min.raw/tb_sunrise_opamp_ac2_fs_vdda_min.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_vdda_min.txt/ac_measures_fs_vdda_min.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/4/5/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_vdda_min.raw/tb_sunrise_opamp_tran_ff_vdda_max.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_vdda_min.raw/tb_sunrise_opamp_ac1_ff_vdda_max.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_vdda_min.raw/tb_sunrise_opamp_ac2_ff_vdda_max.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_vdda_min.txt/ac_measures_ff_vdda_max.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/5/6/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_vdda_max.raw/tb_sunrise_opamp_tran_ss_vdda_max.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_vdda_max.raw/tb_sunrise_opamp_ac1_ss_vdda_max.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_vdda_max.raw/tb_sunrise_opamp_ac2_ss_vdda_max.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_vdda_max.txt/ac_measures_ss_vdda_max.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/6/7/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_vdda_max.raw/tb_sunrise_opamp_tran_sf_vdda_max.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_vdda_max.raw/tb_sunrise_opamp_ac1_sf_vdda_max.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_vdda_max.raw/tb_sunrise_opamp_ac2_sf_vdda_max.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_vdda_max.txt/ac_measures_sf_vdda_max.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/7/8/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_vdda_max.raw/tb_sunrise_opamp_tran_fs_vdda_max.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_vdda_max.raw/tb_sunrise_opamp_ac1_fs_vdda_max.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_vdda_max.raw/tb_sunrise_opamp_ac2_fs_vdda_max.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_vdda_max.txt/ac_measures_fs_vdda_max.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
"







}
C {devices/launcher.sym} -740 60 0 0 {# Process corner sweep for tt, ff, ss, sf, fs
# Assumes stim file has set corner to tt
name=h11
descr="Process / Voltage / Temp corner group (step/stb)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_stg2_STEP_STB_NOISE.spice
xschem netlist
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
################## change to n40 corner ################################
exec sed -i \{s/set xTj = ( 27 )/set xTj = ( -40 )/\} $spicefile
##################  set vdda = vdda_min_n40 ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.3/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.5/1.425/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/tt/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_tt/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_tt/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran.raw/tb_sunrise_opamp_tran_ff_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1.raw/tb_sunrise_opamp_ac1_ff_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2.raw/tb_sunrise_opamp_ac2_ff_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures.txt/ac_measures_ff_vdda_min_n40.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_vdda_min_n40.raw/tb_sunrise_opamp_tran_ss_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_vdda_min_n40.raw/tb_sunrise_opamp_ac1_ss_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_vdda_min_n40.raw/tb_sunrise_opamp_ac2_ss_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_vdda_min_n40.txt/ac_measures_ss_vdda_min_n40.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/2/3/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_vdda_min_n40.raw/tb_sunrise_opamp_tran_sf_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_vdda_min_n40.raw/tb_sunrise_opamp_ac1_sf_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_vdda_min_n40.raw/tb_sunrise_opamp_ac2_sf_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_vdda_min_n40.txt/ac_measures_sf_vdda_min_n40.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/3/4/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_vdda_min_n40.raw/tb_sunrise_opamp_tran_fs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_vdda_min_n40.raw/tb_sunrise_opamp_ac1_fs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_vdda_min_n40.raw/tb_sunrise_opamp_ac2_fs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_vdda_min_n40.txt/ac_measures_fs_vdda_min_n40.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/4/5/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ff_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_ff_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_ff_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_vdda_min_n40.txt/ac_measures_ff_vdda_max_n40.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/5/6/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_vdda_max_n40.raw/tb_sunrise_opamp_tran_ss_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_vdda_max_n40.raw/tb_sunrise_opamp_ac1_ss_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_vdda_max_n40.raw/tb_sunrise_opamp_ac2_ss_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_vdda_max_n40.txt/ac_measures_ss_vdda_max_n40.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/6/7/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_vdda_max_n40.raw/tb_sunrise_opamp_tran_sf_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_vdda_max_n40.raw/tb_sunrise_opamp_ac1_sf_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_vdda_max_n40.raw/tb_sunrise_opamp_ac2_sf_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_vdda_max_n40.txt/ac_measures_sf_vdda_max_n40.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/7/8/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_vdda_max_n40.raw/tb_sunrise_opamp_tran_fs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_vdda_max_n40.raw/tb_sunrise_opamp_ac1_fs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_vdda_max_n40.raw/tb_sunrise_opamp_ac2_fs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_vdda_max_n40.txt/ac_measures_fs_vdda_max_n40.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
################## change to 125 corner ################################
exec sed -i \{s/set xTj = ( -40 )/set xTj = ( 125 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.465/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.575/1.425/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/8/9/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ff_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_ff_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_ff_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_vdda_max_n40.txt/ac_measures_ff_vdda_min_125.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/9/10/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_vdda_min_125.raw/tb_sunrise_opamp_tran_ss_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_vdda_min_125.raw/tb_sunrise_opamp_ac1_ss_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_vdda_min_125.raw/tb_sunrise_opamp_ac2_ss_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_vdda_min_125.txt/ac_measures_ss_vdda_min_125.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/10/11/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_vdda_min_125.raw/tb_sunrise_opamp_tran_sf_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_vdda_min_125.raw/tb_sunrise_opamp_ac1_sf_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_vdda_min_125.raw/tb_sunrise_opamp_ac2_sf_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_vdda_min_125.txt/ac_measures_sf_vdda_min_125.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/11/12/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_vdda_min_125.raw/tb_sunrise_opamp_tran_fs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_vdda_min_125.raw/tb_sunrise_opamp_ac1_fs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_vdda_min_125.raw/tb_sunrise_opamp_ac2_fs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_vdda_min_125.txt/ac_measures_fs_vdda_min_125.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/12/13/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_vdda_min_125.raw/tb_sunrise_opamp_tran_ff_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_vdda_min_125.raw/tb_sunrise_opamp_ac1_ff_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_vdda_min_125.raw/tb_sunrise_opamp_ac2_ff_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_vdda_min_125.txt/ac_measures_ff_vdda_max_125.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/13/14/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_vdda_max_125.raw/tb_sunrise_opamp_tran_ss_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_vdda_max_125.raw/tb_sunrise_opamp_ac1_ss_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_vdda_max_125.raw/tb_sunrise_opamp_ac2_ss_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_vdda_max_125.txt/ac_measures_ss_vdda_max_125.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/14/15/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_vdda_max_125.raw/tb_sunrise_opamp_tran_sf_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_vdda_max_125.raw/tb_sunrise_opamp_ac1_sf_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_vdda_max_125.raw/tb_sunrise_opamp_ac2_sf_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_vdda_max_125.txt/ac_measures_sf_vdda_max_125.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/15/16/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_vdda_max_125.raw/tb_sunrise_opamp_tran_fs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_vdda_max_125.raw/tb_sunrise_opamp_ac1_fs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_vdda_max_125.raw/tb_sunrise_opamp_ac2_fs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_vdda_max_125.txt/ac_measures_fs_vdda_max_125.txt/\} $spicefile
simulate
after 1000 ;# wait 1sec for ngspice to start and read netlist
"

















}
C {devices/launcher.sym} -740 100 0 0 {# Process (w. Res) corner sweep for tt, ff, ss, sf, fs
# Assumes stim file has set corner to tt
name=h6
descr="Process (w. Res) / Voltage / Temp corner group (step/stb)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_stg2_STEP_STB_NOISE.spice
xschem netlist
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
################## change to n40 corner ################################
exec sed -i \{s/set xTj = ( 27 )/set xTj = ( -40 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.3/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.5/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_typ/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/tt/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_tt/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_tt/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1.raw/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2.raw/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures.txt/ac_measures_ff_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_bcs_vdda_min_n40.txt/ac_measures_ss_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/2/3/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_bcs_vdda_min_n40.txt/ac_measures_sf_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/3/4/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_bcs_vdda_min_n40.txt/ac_measures_fs_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/4/5/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_bcs_vdda_min_n40.txt/ac_measures_ff_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/5/6/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_wcs_vdda_min_n40.txt/ac_measures_ss_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/6/7/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_wcs_vdda_min_n40.txt/ac_measures_sf_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/7/8/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_wcs_vdda_min_n40.txt/ac_measures_fs_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/8/9/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_wcs_vdda_min_n40.txt/ac_measures_ff_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/9/10/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_bcs_vdda_max_n40.txt/ac_measures_ss_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/10/11/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_bcs_vdda_max_n40.txt/ac_measures_sf_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/11/12/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_bcs_vdda_max_n40.txt/ac_measures_fs_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/12/13/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_bcs_vdda_max_n40.txt/ac_measures_ff_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/13/14/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_wcs_vdda_max_n40.txt/ac_measures_ss_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/14/15/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_wcs_vdda_max_n40.txt/ac_measures_sf_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/15/16/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_wcs_vdda_max_n40.txt/ac_measures_fs_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
################## change to 125 corner ################################
exec sed -i \{s/set xTj = ( -40 )/set xTj = ( 125 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.465/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.575/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/16/17/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_wcs_vdda_max_n40.txt/ac_measures_ff_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/17/18/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_bcs_vdda_min_125.txt/ac_measures_ss_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/18/19/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_bcs_vdda_min_125.txt/ac_measures_sf_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/19/20/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_bcs_vdda_min_125.txt/ac_measures_fs_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/20/21/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_bcs_vdda_min_125.txt/ac_measures_ff_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/21/22/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_wcs_vdda_min_125.txt/ac_measures_ss_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/22/23/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_wcs_vdda_min_125.txt/ac_measures_sf_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/23/24/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_wcs_vdda_min_125.txt/ac_measures_fs_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/24/25/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_wcs_vdda_min_125.txt/ac_measures_ff_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/25/26/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_bcs_vdda_max_125.txt/ac_measures_ss_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/26/27/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_bcs_vdda_max_125.txt/ac_measures_sf_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/27/28/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_bcs_vdda_max_125.txt/ac_measures_fs_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/28/29/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_bcs_vdda_max_125.txt/ac_measures_ff_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/29/30/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_wcs_vdda_max_125.txt/ac_measures_ss_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/30/31/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_wcs_vdda_max_125.txt/ac_measures_sf_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/31/32/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_wcs_vdda_max_125.txt/ac_measures_fs_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
"

















}
C {devices/noconn.sym} -260 330 1 0 {name=l3}
C {devices/noconn.sym} -360 330 1 0 {name=l4}
C {devices/noconn.sym} -460 330 1 0 {name=l5}
C {devices/launcher.sym} -740 140 0 0 {# Process (w. Res) corner sweep for tt, ff, ss, sf, fs
# Assumes stim file has set corner to tt
name=h12
descr="Process (w. Res) / Voltage / Temp corner group (noise)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_stg2_STEP_STB_NOISE.spice
xschem netlist
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
################## change to n40 corner ################################
exec sed -i \{s/set xTj = ( 27 )/set xTj = ( -40 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.3/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.5/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_typ/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/tt/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_tt/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_tt/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density.raw/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k.txt/noise_ipr_1k_ff_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_bcs_vdda_min_n40.txt/noise_ipr_1k_ss_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/2/3/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_bcs_vdda_min_n40.txt/noise_ipr_1k_sf_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/3/4/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_bcs_vdda_min_n40.txt/noise_ipr_1k_fs_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/4/5/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_bcs_vdda_min_n40.txt/noise_ipr_1k_ff_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/5/6/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_wcs_vdda_min_n40.txt/noise_ipr_1k_ss_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/6/7/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_wcs_vdda_min_n40.txt/noise_ipr_1k_sf_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/7/8/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_wcs_vdda_min_n40.txt/noise_ipr_1k_fs_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/8/9/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_wcs_vdda_min_n40.txt/noise_ipr_1k_ff_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/9/10/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_bcs_vdda_max_n40.txt/noise_ipr_1k_ss_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/10/11/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_bcs_vdda_max_n40.txt/noise_ipr_1k_sf_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/11/12/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_bcs_vdda_max_n40.txt/noise_ipr_1k_fs_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/12/13/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_bcs_vdda_max_n40.txt/noise_ipr_1k_ff_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/13/14/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_wcs_vdda_max_n40.txt/noise_ipr_1k_ss_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/14/15/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_wcs_vdda_max_n40.txt/noise_ipr_1k_sf_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/15/16/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_wcs_vdda_max_n40.txt/noise_ipr_1k_fs_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
################## change to 125 corner ################################
exec sed -i \{s/set xTj = ( -40 )/set xTj = ( 125 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.465/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.575/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/16/17/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_wcs_vdda_max_n40.txt/noise_ipr_1k_ff_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/17/18/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_bcs_vdda_min_125.txt/noise_ipr_1k_ss_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/18/19/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_bcs_vdda_min_125.txt/noise_ipr_1k_sf_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/19/20/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_bcs_vdda_min_125.txt/noise_ipr_1k_fs_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/20/21/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_bcs_vdda_min_125.txt/noise_ipr_1k_ff_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/21/22/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_wcs_vdda_min_125.txt/noise_ipr_1k_ss_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/22/23/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_wcs_vdda_min_125.txt/noise_ipr_1k_sf_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/23/24/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_wcs_vdda_min_125.txt/noise_ipr_1k_fs_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/24/25/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_wcs_vdda_min_125.txt/noise_ipr_1k_ff_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/25/26/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_bcs_vdda_max_125.txt/noise_ipr_1k_ss_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/26/27/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_bcs_vdda_max_125.txt/noise_ipr_1k_sf_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/27/28/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_bcs_vdda_max_125.txt/noise_ipr_1k_fs_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/28/29/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_bcs_vdda_max_125.txt/noise_ipr_1k_ff_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/29/30/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_wcs_vdda_max_125.txt/noise_ipr_1k_ss_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/30/31/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_wcs_vdda_max_125.txt/noise_ipr_1k_sf_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/31/32/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_wcs_vdda_max_125.txt/noise_ipr_1k_fs_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 5000 ;# wait 1sec for ngspice to start and read netlist
"

















}
C {launcher.sym} 2020 180 0 0 {name=h13
descr="load_AC_NOISE_waveforms" 
tclcommand="xschem raw_read $netlist_dir/tb_sunrise_opamp_noise_density.raw"


}
C {devices/lab_wire.sym} -780 700 0 1 {name=p3 sig_type=std_logic lab=vih

}
C {devices/lab_wire.sym} -770 1200 0 1 {name=p2 sig_type=std_logic lab=vil
}
C {devices/lab_wire.sym} 40 960 0 1 {name=p9 sig_type=std_logic lab=vout

}
C {devices/capa.sym} 100 1030 0 0 {name=C3
m=1
value=\{xCl\}
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 100 1080 1 1 {name=p28 sig_type=std_logic lab=vssa

}
C {devices/vsource.sym} -800 1290 0 0 {name=Vvcm value="\{xvcm-20m\}"
format="@name @pinlist @value"}
C {devices/vsource.sym} -800 1010 0 0 {name=Vvinp value="50m"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -800 1340 1 1 {name=p30 sig_type=std_logic lab=vssa

}
C {devices/vsource.sym} -660 390 0 0 {name=Vvss_pcb value="xvocm"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -660 440 1 1 {name=p1 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -660 350 1 0 {name=p4 sig_type=std_logic lab=vss_pcb

}
C {devices/noconn.sym} -160 320 1 0 {name=l2}
C {devices/vsource.sym} -800 830 0 1 {name=Vstep value="pwl (0 0 0.5u 0 \{0.5u+xtrf\} \{xstep_en*xstep\})"
format="@name @pinlist @value"
}
C {devices/launcher.sym} -740 180 0 0 {# Process (w. Res) corner sweep for tt, ff, ss, sf, fs
# Assumes stim file has set corner to tt
name=h8
descr="Process (w. Res) / Voltage / Temp corner group (step/stb/noise)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_bias_stg2_STEP_STB_NOISE.spice
xschem netlist
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
################## change to n40 corner ################################
exec sed -i \{s/set xTj = ( 27 )/set xTj = ( -40 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.3/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.5/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_typ/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/tt/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_tt/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_tt/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1.raw/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2.raw/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures.txt/ac_measures_ff_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density.raw/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k.txt/noise_ipr_1k_ff_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_bcs_vdda_min_n40.txt/ac_measures_ss_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_bcs_vdda_min_n40.txt/noise_ipr_1k_ss_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/2/3/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_bcs_vdda_min_n40.txt/ac_measures_sf_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_bcs_vdda_min_n40.txt/noise_ipr_1k_sf_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/3/4/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_bcs_vdda_min_n40.txt/ac_measures_fs_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_bcs_vdda_min_n40.txt/noise_ipr_1k_fs_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/4/5/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_bcs_vdda_min_n40.txt/ac_measures_ff_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_bcs_vdda_min_n40.txt/noise_ipr_1k_ff_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/5/6/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_wcs_vdda_min_n40.txt/ac_measures_ss_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_wcs_vdda_min_n40.txt/noise_ipr_1k_ss_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/6/7/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_wcs_vdda_min_n40.txt/ac_measures_sf_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_wcs_vdda_min_n40.txt/noise_ipr_1k_sf_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/7/8/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_wcs_vdda_min_n40.txt/ac_measures_fs_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_wcs_vdda_min_n40.txt/noise_ipr_1k_fs_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/8/9/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_wcs_vdda_min_n40.txt/ac_measures_ff_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_wcs_vdda_min_n40.txt/noise_ipr_1k_ff_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/9/10/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_bcs_vdda_max_n40.txt/ac_measures_ss_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_bcs_vdda_max_n40.txt/noise_ipr_1k_ss_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/10/11/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_bcs_vdda_max_n40.txt/ac_measures_sf_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_bcs_vdda_max_n40.txt/noise_ipr_1k_sf_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/11/12/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_bcs_vdda_max_n40.txt/ac_measures_fs_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_bcs_vdda_max_n40.txt/noise_ipr_1k_fs_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/12/13/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_bcs_vdda_max_n40.txt/ac_measures_ff_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_bcs_vdda_max_n40.txt/noise_ipr_1k_ff_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/13/14/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_wcs_vdda_max_n40.txt/ac_measures_ss_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_wcs_vdda_max_n40.txt/noise_ipr_1k_ss_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/14/15/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_wcs_vdda_max_n40.txt/ac_measures_sf_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_wcs_vdda_max_n40.txt/noise_ipr_1k_sf_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/15/16/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_wcs_vdda_max_n40.txt/ac_measures_fs_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_wcs_vdda_max_n40.txt/noise_ipr_1k_fs_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
################## change to 125 corner ################################
exec sed -i \{s/set xTj = ( -40 )/set xTj = ( 125 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.465/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.575/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/16/17/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_wcs_vdda_max_n40.txt/ac_measures_ff_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_wcs_vdda_max_n40.txt/noise_ipr_1k_ff_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/17/18/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_bcs_vdda_min_125.txt/ac_measures_ss_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_bcs_vdda_min_125.txt/noise_ipr_1k_ss_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/18/19/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_bcs_vdda_min_125.txt/ac_measures_sf_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_bcs_vdda_min_125.txt/noise_ipr_1k_sf_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/19/20/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_bcs_vdda_min_125.txt/ac_measures_fs_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_bcs_vdda_min_125.txt/noise_ipr_1k_fs_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/20/21/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_bcs_vdda_min_125.txt/ac_measures_ff_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_bcs_vdda_min_125.txt/noise_ipr_1k_ff_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/21/22/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_wcs_vdda_min_125.txt/ac_measures_ss_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_wcs_vdda_min_125.txt/noise_ipr_1k_ss_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/22/23/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_wcs_vdda_min_125.txt/ac_measures_sf_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_wcs_vdda_min_125.txt/noise_ipr_1k_sf_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/23/24/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_wcs_vdda_min_125.txt/ac_measures_fs_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_wcs_vdda_min_125.txt/noise_ipr_1k_fs_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/24/25/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_wcs_vdda_min_125.txt/ac_measures_ff_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_wcs_vdda_min_125.txt/noise_ipr_1k_ff_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/25/26/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_bcs_vdda_max_125.txt/ac_measures_ss_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_bcs_vdda_max_125.txt/noise_ipr_1k_ss_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/26/27/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_bcs_vdda_max_125.txt/ac_measures_sf_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_bcs_vdda_max_125.txt/noise_ipr_1k_sf_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/27/28/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_bcs_vdda_max_125.txt/ac_measures_fs_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_bcs_vdda_max_125.txt/noise_ipr_1k_fs_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/28/29/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_fs_res_bcs_vdda_max_125.txt/ac_measures_ff_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_fs_res_bcs_vdda_max_125.txt/noise_ipr_1k_ff_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/29/30/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ff_res_wcs_vdda_max_125.txt/ac_measures_ss_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ff_res_wcs_vdda_max_125.txt/noise_ipr_1k_ss_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/30/31/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_ss_res_wcs_vdda_max_125.txt/ac_measures_sf_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_ss_res_wcs_vdda_max_125.txt/noise_ipr_1k_sf_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/31/32/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac1_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac1_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac2_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac2_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/ac_measures_sf_res_wcs_vdda_max_125.txt/ac_measures_fs_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_noise_density_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_noise_density_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/noise_ipr_1k_sf_res_wcs_vdda_max_125.txt/noise_ipr_1k_fs_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 15000 ;# wait 1sec for ngspice to start and read netlist
"

















}
C {devices/lab_wire.sym} -1960 1360 0 1 {name=p36 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -1620 1120 0 0 {name=p37 sig_type=std_logic lab=vssa

}
C {devices/vsource.sym} -1360 1290 0 0 {name=Vvload1 value="xvload"
format="@name @pinlist @value"}
C {devices/vsource.sym} -1240 1290 0 0 {name=Vvload2 value="xvload"
format="@name @pinlist @value"}
C {lab_wire.sym} -3320 1260 0 1 {name=p38 sig_type=std_logic lab=vssa}
C {sg13g2_pr/sg13_hv_nmos.sym} -3260 1260 0 1 {name=Mnbias_ip_lhs
l=8.28u
w=6u
ng=1
m=4
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} -2940 1260 0 0 {name=p39 sig_type=std_logic lab=vssa}
C {sg13g2_pr/sg13_hv_nmos.sym} -3000 1260 0 0 {name=Mnbias_ip_rhs
l=8.28u
w=6u
ng=1
m=4
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} -3020 700 0 1 {name=p40 sig_type=std_logic lab=vdda_hv}
C {lab_wire.sym} -3020 520 0 1 {name=p41 sig_type=std_logic lab=vdda_hv}
C {sg13g2_pr/sg13_hv_pmos.sym} -2960 700 0 1 {name=Mpcasc_stg1_bias_lhs
l=0.43u
w=7.5u
ng=1
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_pmos.sym} -2960 520 0 1 {name=Mpbias_stg1_bias_lhs
l=4.9u
w=7.5u
ng=1
m=4
model=sg13_hv_pmos
spiceprefix=X
}
C {lab_wire.sym} -2580 700 0 0 {name=p42 sig_type=std_logic lab=vdda_hv}
C {lab_wire.sym} -2580 520 0 0 {name=p43 sig_type=std_logic lab=vdda_hv}
C {sg13g2_pr/sg13_hv_pmos.sym} -2640 700 0 0 {name=Mpcasc_stg1_bias_rhs
l=0.43u
w=7.5u
ng=1
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_pmos.sym} -2640 520 0 0 {name=Mpbias_stg1_bias_rhs
l=4.9u
w=7.5u
ng=1
m=4
model=sg13_hv_pmos
spiceprefix=X
}
C {lab_wire.sym} -2940 960 0 1 {name=p67 sig_type=std_logic lab=vpcasc_in}
C {lab_wire.sym} -2950 780 0 1 {name=p68 sig_type=std_logic lab=vpbias_in}
C {sg13g2_pr/rppd.sym} -2980 870 0 0 {name=R4
w=0.5e-6
l=146.97e-6
model=rppd
body=vssa
spiceprefix=X
b=0
m=1
}
C {lab_wire.sym} -2980 560 1 1 {name=p44 sig_type=std_logic lab=vd_pbias_bias_lhs}
C {lab_wire.sym} -2620 560 1 1 {name=p58 sig_type=std_logic lab=vd_pbias_bias_rhs1}
C {isource.sym} -3280 780 0 0 {name=I2 value="xibias"}
C {devices/lab_wire.sym} -2740 420 0 0 {name=p60 sig_type=std_logic lab=vdda_hv

}
C {devices/lab_wire.sym} -3140 1360 0 1 {name=p61 sig_type=std_logic lab=vssa

}
C {isource.sym} -1940 690 0 0 {name=I3 value="xibias"}
C {devices/vsource.sym} -2600 1290 0 0 {name=Vint_bias value="\{xint_bias_en*xvdda_lv\}"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -2370 1260 0 0 {name=p62 sig_type=std_logic lab=pdb

}
C {devices/lab_wire.sym} -2440 1240 0 0 {name=p63 sig_type=std_logic lab=int_bias

}
C {devices/lab_wire.sym} -2050 1220 0 0 {name=p64 sig_type=std_logic lab=int_bias_int

}
C {devices/lab_wire.sym} -2040 1240 0 0 {name=p65 sig_type=std_logic lab=int_bias_intb

}
C {devices/lab_wire.sym} -2050 1260 0 0 {name=p66 sig_type=std_logic lab=ext_bias_int

}
C {devices/lab_wire.sym} -2040 1280 0 0 {name=p69 sig_type=std_logic lab=ext_bias_intb

}
C {devices/lab_wire.sym} -2280 1140 0 0 {name=p70 sig_type=std_logic lab=vdda_lv

}
C {devices/lab_wire.sym} -1620 1080 0 0 {name=p71 sig_type=std_logic lab=ndio

}
C {lab_wire.sym} -1720 990 1 0 {name=p72 sig_type=std_logic lab=int_bias_int_hv}
C {lab_wire.sym} -1760 1000 1 0 {name=p73 sig_type=std_logic lab=int_bias_intb_hv}
C {lab_wire.sym} -1640 990 1 0 {name=p74 sig_type=std_logic lab=ext_bias_int_hv}
C {lab_wire.sym} -1680 1000 1 0 {name=p75 sig_type=std_logic lab=ext_bias_intb_hv}
C {ideal_switch.sym} -1860 930 1 0 {name=x2}
C {devices/lab_wire.sym} -1920 840 0 0 {name=p76 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -1840 760 1 0 {name=p77 sig_type=std_logic lab=vdda_hv

}
C {lab_wire.sym} -1660 840 0 0 {name=p78 sig_type=std_logic lab=ext_bias_int_hv}
C {ideal_switch.sym} -2250 1080 0 1 {name=x3}
C {devices/lab_wire.sym} -2080 1060 0 1 {name=p79 sig_type=std_logic lab=vdda_hv

}
C {devices/vsource.sym} -1940 970 0 0 {name=Viin_id value=0
format="@name @pinlist @value"}
C {devices/vsource.sym} -2040 1080 1 0 {name=Viin_mir value=0
format="@name @pinlist @value"}
C {devices/vsource.sym} -1850 1080 3 0 {name=Viin value=0
format="@name @pinlist @value"}
C {lab_wire.sym} -2200 1120 0 1 {name=p80 sig_type=std_logic lab=vssa}
C {devices/lab_wire.sym} -2050 1200 0 0 {name=p81 sig_type=std_logic lab=pdb_int

}
C {devices/lab_wire.sym} -2050 1180 0 0 {name=p82 sig_type=std_logic lab=pd_int

}
C {sg13g2_stdcells/sg13g2_or2_1.sym} -2370 920 1 0 {name=x4 VDD=vdda_hv VSS=vssa prefix=sg13g2_ }
C {lab_wire.sym} -2180 720 3 0 {name=p83 sig_type=std_logic lab=int_bias_int_hv}
C {devices/lab_wire.sym} -2140 770 3 0 {name=p84 sig_type=std_logic lab=pd_int_hv

}
C {lab_wire.sym} -1140 950 1 0 {name=p85 sig_type=std_logic lab=pd_int_hv}
C {lab_wire.sym} -1120 960 1 0 {name=p86 sig_type=std_logic lab=pdb_int_hv}
C {devices/vsource.sym} -2500 1290 0 1 {name=Vstep2 value="pwl (0 0 2u 0 \{2u+xtrf\} xvdda_lv 4u xvdda_lv \{4u+xtrf\} 0)"
format="@name @pinlist @value"
}
C {devices/lab_wire.sym} -1780 600 0 0 {name=p87 sig_type=std_logic lab=vdda_hv

}
C {devices/vsource.sym} -2420 1310 0 0 {name=Vpdb1 value="\{xpdb*xvdda_lv\}"
format="@name @pinlist @value"}
C {noconn.sym} -2420 1280 0 0 {name=l14}
C {noconn.sym} -2500 1260 0 0 {name=l15}
C {sunrise/sunrise_logic_pd_bias.sym} -2280 1320 0 0 {name=x1}
C {sunrise/sunrise_bias.sym} -1420 1080 0 0 {name=xibias}
C {vcvs.sym} -2300 140 0 0 {name=E4 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -2370 160 0 0 {name=p88 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -2360 120 0 0 {name=p89 sig_type=std_logic lab=int_bias_int}
C {lab_wire.sym} -2300 80 1 0 {name=p90 sig_type=std_logic lab=int_bias_int_hv}
C {lab_wire.sym} -2300 260 1 0 {name=p91 sig_type=std_logic lab=vssa}
C {vcvs.sym} -1960 140 0 0 {name=E1 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -2030 160 0 0 {name=p92 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -2020 120 0 0 {name=p93 sig_type=std_logic lab=int_bias_intb}
C {lab_wire.sym} -1960 80 1 0 {name=p94 sig_type=std_logic lab=int_bias_intb_hv}
C {lab_wire.sym} -1960 260 1 0 {name=p95 sig_type=std_logic lab=vssa}
C {vcvs.sym} -1600 140 0 0 {name=E2 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -1670 160 0 0 {name=p96 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -1660 120 0 0 {name=p97 sig_type=std_logic lab=ext_bias_int}
C {lab_wire.sym} -1600 80 1 0 {name=p98 sig_type=std_logic lab=ext_bias_int_hv}
C {lab_wire.sym} -1600 260 1 0 {name=p99 sig_type=std_logic lab=vssa}
C {vcvs.sym} -1260 140 0 0 {name=E3 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -1330 160 0 0 {name=p100 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -1320 120 0 0 {name=p101 sig_type=std_logic lab=ext_bias_intb}
C {lab_wire.sym} -1260 80 1 0 {name=p102 sig_type=std_logic lab=ext_bias_intb_hv}
C {lab_wire.sym} -1260 260 1 0 {name=p103 sig_type=std_logic lab=vssa}
C {vcvs.sym} -3040 140 0 0 {name=E5 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -3110 160 0 0 {name=p104 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -3100 120 0 0 {name=p105 sig_type=std_logic lab=pdb_int}
C {lab_wire.sym} -3040 80 1 0 {name=p106 sig_type=std_logic lab=pdb_int_hv}
C {lab_wire.sym} -3040 260 1 0 {name=p107 sig_type=std_logic lab=vssa}
C {vcvs.sym} -2700 140 0 0 {name=E6 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -2770 160 0 0 {name=p108 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -2760 120 0 0 {name=p109 sig_type=std_logic lab=pd_int}
C {lab_wire.sym} -2700 80 1 0 {name=p110 sig_type=std_logic lab=pd_int_hv}
C {lab_wire.sym} -2700 260 1 0 {name=p111 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -1480 1340 1 0 {name=p112 sig_type=std_logic lab=ibias_in_5u}
C {devices/vsource.sym} -1480 1210 0 0 {name=Viprb_bias_ value=0
format="@name @pinlist @value"}
C {sunrise/sunrise_STG2_loop.sym} -320 1260 0 0 {name=xstg2}
C {devices/loopgainprobe.sym} 40 1000 3 0 {name=xstb}
C {lab_wire.sym} -540 860 0 0 {name=p23 sig_type=std_logic lab=ibias_in_5u}
C {lab_wire.sym} -540 940 0 0 {name=p27 sig_type=std_logic lab=pd_int_hv}
C {lab_wire.sym} -540 960 0 0 {name=p31 sig_type=std_logic lab=pdb_int_hv}
C {devices/lab_wire.sym} -20 900 0 1 {name=p32 sig_type=std_logic lab=vss_pcb

}
C {devices/lab_wire.sym} -320 780 0 0 {name=p33 sig_type=std_logic lab=vdda_hv

}
C {devices/lab_wire.sym} -300 1120 1 1 {name=p34 sig_type=std_logic lab=vssa

}
C {sg13cmos5l_stdcells/sg13cmos5l_or2_1.sym} -2160 920 1 0 {name=x5 VDD=vdda_hv VSS=vssa prefix=sg13cmos5l_ }
