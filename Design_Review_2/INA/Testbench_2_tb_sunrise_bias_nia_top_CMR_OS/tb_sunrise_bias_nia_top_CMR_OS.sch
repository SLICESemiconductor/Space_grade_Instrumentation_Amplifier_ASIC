v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 260 220 1060 620 {flags=graph
y1=1.7
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=5e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="vinp
vout
vfb
vcm"
color="4 8 10 7"
dataset=-1
unitx=1
logx=0
logy=0
sim_type=tran
autoload=1
rawfile=$netlist_dir/tb_sunrise_opamp_tran.raw}
B 2 1080 220 1880 620 {flags=graph
y1=-210
y2=-40
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0
node="\\"tt27vnomrnom;vout db20()\\"

\\"ff125vmaxrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ff_res_bcs_vdda_max_125.raw\\"
\\"ffn40vmaxrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ff_res_bcs_vdda_max_n40.raw\\"
\\"ff125vminrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ff_res_bcs_vdda_min_125.raw\\"
\\"ffn40vminrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ff_res_bcs_vdda_min_n40.raw\\"

\\"ff125vmaxrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ff_res_wcs_vdda_max_125.raw\\"
\\"ffn40vmaxrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ff_res_wcs_vdda_max_n40.raw\\"
\\"ff125vminrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ff_res_wcs_vdda_min_125.raw\\"
\\"ffn40vminrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ff_res_wcs_vdda_min_n40.raw\\"

\\"fs125vmaxrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_fs_res_bcs_vdda_max_125.raw\\"
\\"fsn40vmaxrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_fs_res_bcs_vdda_max_n40.raw\\"
\\"fs125vminrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_fs_res_bcs_vdda_min_125.raw\\"
\\"fsn40vminrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_fs_res_bcs_vdda_min_n40.raw\\"

\\"fs125vmaxrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_fs_res_wcs_vdda_max_125.raw\\"
\\"fsn40vmaxrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_fs_res_wcs_vdda_max_n40.raw\\"
\\"fs125vminrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_fs_res_wcs_vdda_min_125.raw\\"
\\"fsn40vminrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_fs_res_wcs_vdda_min_n40.raw\\"

\\"sf125vmaxrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_sf_res_bcs_vdda_max_125.raw\\"
\\"sfn40vmaxrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_sf_res_bcs_vdda_max_n40.raw\\"
\\"sf125vminrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_sf_res_bcs_vdda_min_125.raw\\"
\\"sfn40vminrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_sf_res_bcs_vdda_min_n40.raw\\"

\\"sf125vmaxrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_sf_res_wcs_vdda_max_125.raw\\"
\\"sfn40vmaxrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_sf_res_wcs_vdda_max_n40.raw\\"
\\"sf125vminrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_sf_res_wcs_vdda_min_125.raw\\"
\\"sfn40vminrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_sf_res_wcs_vdda_min_n40.raw\\"

\\"ss125vmaxrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ss_res_bcs_vdda_max_125.raw\\"
\\"ssn40vmaxrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ss_res_bcs_vdda_max_n40.raw\\"
\\"ss125vminrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ss_res_bcs_vdda_min_125.raw\\"
\\"ssn40vminrbcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ss_res_bcs_vdda_min_n40.raw\\"

\\"ss125vmaxrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ss_res_wcs_vdda_max_125.raw\\"
\\"ssn40vmaxrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ss_res_wcs_vdda_max_n40.raw\\"
\\"ss125vminrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ss_res_wcs_vdda_min_125.raw\\"
\\"ssn40vminrwcs;vout db20()%$netlist_dir/tb_sunrise_opamp_ac_ss_res_wcs_vdda_min_n40.raw\\""
color="10 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 4 5 6 7 8 9 10 11 12 13 14 15 16 17"
dataset=-1
unitx=1
logx=1
logy=0
rawfile=$netlist_dir/tb_sunrise_opamp_ac.raw
sim_type=ac
autoload=1
x2=9
vlegend=1}
B 2 260 640 1060 1040 {flags=graph
y1=-0.00026
y2=-2e-07
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=5e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/tb_sunrise_opamp_tran.raw
sim_type=tran
autoload=1
hcursor1_y=2.6035
color="4 4"
node="i(viout)
i(vvdda_hv)"}
P 4 1 -1890 460 {}
T {TRANSIENT RESPONSE} 540 130 0 0 0.4 0.4 {}
T {CMR ANALYSIS} 1380 130 0 0 0.4 0.4 {}
T {5u} -3400 1340 0 0 0.4 0.4 {}
T {5u} -3110 1340 0 0 0.4 0.4 {}
T {PU} -2540 1340 0 0 0.4 0.4 {}
T {PDPUPD} -2650 1340 0 0 0.4 0.4 {}
N -760 420 -760 440 {
lab=GND}
N -760 320 -760 360 {
lab=vssa}
N 40 720 40 1100 {lab=vout}
N -560 420 -560 460 {
lab=vssa}
N -560 330 -560 370 {
lab=vdda_hv}
N -460 420 -460 460 {
lab=vssa}
N -460 330 -460 370 {
lab=vnbias}
N -360 420 -360 460 {
lab=vssa}
N -360 330 -360 370 {
lab=vncasc}
N -260 420 -260 460 {
lab=vssa}
N -260 330 -260 370 {
lab=vpcasc}
N -160 420 -160 460 {
lab=vssa}
N -160 320 -160 360 {
lab=vdda_lv}
N -660 420 -660 460 {
lab=vssa}
N -660 330 -660 370 {
lab=vcm}
N -720 700 -500 700 {lab=vinp}
N -720 700 -720 840 {lab=vinp}
N 1520 810 1560 810 {lab=bin_out_9}
N 1520 830 1560 830 {lab=bin_out_8}
N 1520 850 1560 850 {lab=bin_out_7}
N 1520 870 1560 870 {lab=bin_out_6}
N 1520 890 1560 890 {lab=bin_out_5}
N 1520 910 1560 910 {lab=bin_out_4}
N 1520 930 1560 930 {lab=bin_out_3}
N 1520 950 1560 950 {lab=bin_out_2}
N 1520 970 1560 970 {lab=rdac_ctrl_1}
N 1520 990 1560 990 {lab=rdac_ctrl_0}
N 1200 830 1220 830 {lab=vssa}
N 1200 810 1220 810 {lab=vdda_lv}
N -220 1320 40 1320 {lab=vcm}
N -680 1100 -460 1100 {lab=rdac_ctrlb_onehot_hv[2:0]}
N -680 1080 -460 1080 {lab=rdac_ctrl_onehot_hv[2:0]}
N -320 980 -320 1000 {lab=vdda_hv}
N -400 980 -320 980 {lab=vdda_hv}
N -320 1200 -320 1220 {lab=vssa}
N -420 1220 -320 1220 {lab=vssa}
N -220 900 -220 1000 {lab=#net1}
N -720 900 -720 1320 {lab=vcm}
N 40 1160 40 1320 {lab=vcm}
N -2130 300 -2090 300 {lab=vssa}
N -1830 280 -1650 280 {lab=rdac_ctrl_onehot[2:0]}
N -1490 340 -1320 340 {lab=rdac_ctrlb_onehot_hv[2:0]}
N -1690 420 -1650 420 {lab=vssa}
N -1690 160 -1650 160 {lab=vdda_lv}
N -1490 200 -1320 200 {lab=rdac_ctrl_onehot_hv[2:0]}
N -2270 280 -2090 280 {lab=rdac_ctrl_1,rdac_ctrl_0}
N -2150 260 -2090 260 {lab=vdda_lv}
N -1750 1080 -1710 1080 {
lab=vssa}
N -1470 1280 -1470 1320 {
lab=vssa}
N -1470 1120 -1470 1220 {lab=#net2}
N -1350 1280 -1350 1320 {
lab=vssa}
N -1350 1120 -1350 1220 {lab=#net3}
N -1470 1320 -1350 1320 {lab=vssa}
N -3430 1220 -3390 1220 {lab=vssa}
N -3390 1250 -3390 1320 {lab=vssa}
N -3390 1120 -3390 1190 {lab=#net4}
N -3090 1220 -3050 1220 {lab=vssa}
N -3090 1250 -3090 1320 {lab=vssa}
N -3270 1220 -3130 1220 {lab=#net4}
N -3390 1120 -3270 1120 {lab=#net4}
N -3270 1120 -3270 1220 {lab=#net4}
N -3350 1220 -3270 1220 {lab=#net4}
N -3130 660 -3090 660 {lab=vdda_hv}
N -3130 480 -3090 480 {lab=vdda_hv}
N -3090 380 -3090 450 {lab=vdda_hv}
N -3090 510 -3090 630 {lab=vd_pbias_bias_lhs}
N -3090 920 -3090 1190 {lab=vpcasc_in}
N -3090 740 -3090 800 {lab=vpbias_in}
N -3090 740 -2970 740 {lab=vpbias_in}
N -3090 690 -3090 740 {lab=vpbias_in}
N -3050 480 -2970 480 {lab=vpbias_in}
N -3090 920 -2930 920 {lab=vpcasc_in}
N -3090 860 -3090 920 {lab=vpcasc_in}
N -3050 660 -2930 660 {lab=vpcasc_in}
N -2730 660 -2690 660 {lab=vdda_hv}
N -2730 480 -2690 480 {lab=vdda_hv}
N -2730 380 -2730 450 {lab=vdda_hv}
N -2730 510 -2730 630 {lab=vd_pbias_bias_rhs1}
N -2970 480 -2770 480 {lab=vpbias_in}
N -2930 660 -2770 660 {lab=vpcasc_in}
N -3090 380 -2730 380 {lab=vdda_hv}
N -3390 1320 -3090 1320 {lab=vssa}
N -2970 480 -2970 740 {lab=vpbias_in}
N -2930 660 -2930 920 {lab=vpcasc_in}
N -3390 380 -3090 380 {lab=vdda_hv}
N -3390 380 -3390 710 {lab=vdda_hv}
N -3390 770 -3390 1120 {lab=#net4}
N -2730 690 -2730 1040 {lab=#net5}
N -2370 1280 -2370 1320 {lab=vssa}
N -2710 1200 -2470 1200 {lab=int_bias}
N -2710 1200 -2710 1220 {lab=int_bias}
N -2710 1280 -2710 1320 {lab=vssa}
N -2530 1320 -2370 1320 {
lab=vssa}
N -2250 1180 -2150 1180 {lab=int_bias_int}
N -2250 1200 -2150 1200 {lab=int_bias_intb}
N -2250 1220 -2150 1220 {lab=ext_bias_int}
N -2250 1240 -2150 1240 {lab=ext_bias_intb}
N -1830 1000 -1710 1000 {lab=int_bias_int_hv}
N -1870 1020 -1710 1020 {lab=int_bias_intb_hv}
N -2050 560 -2050 620 {lab=vdda_hv}
N -2090 560 -2050 560 {lab=vdda_hv}
N -2370 1320 -1470 1320 {
lab=vssa}
N -1750 840 -1750 960 {lab=ext_bias_int_hv}
N -1790 980 -1710 980 {lab=ext_bias_intb_hv}
N -1790 840 -1790 980 {lab=ext_bias_intb_hv}
N -1750 960 -1710 960 {lab=ext_bias_int_hv}
N -1870 840 -1870 1020 {lab=int_bias_intb_hv}
N -1830 840 -1830 1000 {lab=int_bias_int_hv}
N -1270 980 -1230 980 {
lab=pdb_int_hv}
N -1510 560 -1510 920 {lab=vdda_hv}
N -2050 740 -1970 740 {lab=#net6}
N -2050 680 -2050 740 {lab=#net6}
N -2050 850 -1970 850 {lab=#net7}
N -2050 800 -2010 800 {
lab=vssa}
N -1950 700 -1950 740 {
lab=vdda_hv}
N -1910 800 -1750 800 {lab=ext_bias_int_hv}
N -2730 1040 -2320 1040 {lab=#net5}
N -2210 1020 -2170 1020 {
lab=vdda_hv}
N -2050 850 -2050 900 {lab=#net7}
N -2050 960 -2050 1040 {lab=#net8}
N -2210 1040 -2180 1040 {lab=#net9}
N -2120 1040 -2050 1040 {lab=#net8}
N -2050 1040 -1990 1040 {lab=#net8}
N -1930 1040 -1710 1040 {lab=ndio}
N -2310 1080 -2270 1080 {lab=vssa}
N -2250 1160 -2150 1160 {lab=pdb_int}
N -2250 1140 -2150 1140 {lab=pd_int}
N -2290 660 -2290 820 {lab=int_bias_int_hv}
N -2250 720 -2250 820 {lab=pd_int_hv}
N -2270 940 -2270 980 {lab=#net10}
N -1270 960 -1250 960 {
lab=pd_int_hv}
N -1250 840 -1250 960 {lab=pd_int_hv}
N -1230 840 -1230 980 {lab=pdb_int_hv}
N -2530 1300 -2530 1320 {lab=vssa}
N -2610 1320 -2530 1320 {
lab=vssa}
N -2610 1280 -2610 1320 {lab=vssa}
N -2710 1320 -2610 1320 {
lab=vssa}
N -2050 560 -1510 560 {lab=vdda_hv}
N -3090 1320 -2710 1320 {lab=vssa}
N -2450 1100 -2370 1100 {lab=vdda_lv}
N -2630 -80 -2550 -80 {lab=vssa}
N -2510 -70 -2510 20 {lab=vssa}
N -2510 -300 -2510 -130 {lab=int_bias_int_hv}
N -2710 -120 -2550 -120 {lab=int_bias_int}
N -2290 -80 -2210 -80 {lab=vssa}
N -2170 -70 -2170 20 {lab=vssa}
N -2170 -300 -2170 -130 {lab=int_bias_intb_hv}
N -2370 -120 -2210 -120 {lab=int_bias_intb}
N -1930 -80 -1850 -80 {lab=vssa}
N -1810 -70 -1810 20 {lab=vssa}
N -1810 -300 -1810 -130 {lab=ext_bias_int_hv}
N -2010 -120 -1850 -120 {lab=ext_bias_int}
N -1590 -80 -1510 -80 {lab=vssa}
N -1470 -70 -1470 20 {lab=vssa}
N -1470 -300 -1470 -130 {lab=ext_bias_intb_hv}
N -1670 -120 -1510 -120 {lab=ext_bias_intb}
N -3370 -80 -3290 -80 {lab=vssa}
N -3250 -70 -3250 20 {lab=vssa}
N -3250 -300 -3250 -130 {lab=pdb_int_hv}
N -3450 -120 -3290 -120 {lab=pdb_int}
N -3030 -80 -2950 -80 {lab=vssa}
N -2910 -70 -2910 20 {lab=vssa}
N -2910 -300 -2910 -130 {lab=pd_int_hv}
N -3110 -120 -2950 -120 {lab=pd_int}
N -1590 1200 -1590 1300 {lab=ibias_in_5u}
N -1590 1120 -1590 1140 {lab=#net11}
N -2530 1220 -2470 1220 {lab=pdb}
N -2530 1220 -2530 1240 {lab=pdb}
N -1040 410 -1040 450 {
lab=vssa}
N -1040 320 -1040 360 {
lab=vdda_hv_opamp}
N -600 680 -500 680 {lab=ibias_in_5u}
N -570 760 -500 760 {lab=pd_int_hv}
N -570 780 -500 780 {lab=pdb_int_hv}
N -360 920 -320 920 {lab=vssa}
N -400 580 -360 580 {
lab=vdda_hv_opamp}
N -360 580 -360 620 {lab=vdda_hv_opamp}
N -360 900 -360 920 {lab=vssa}
N -220 1200 -220 1320 {lab=vcm}
N -720 1320 -220 1320 {lab=vcm}
N -80 720 40 720 {lab=vout}
C {devices/vsource.sym} -720 870 0 0 {name=Vvinp value="xvinp"
format="@name @pinlist @value"}
C {devices/vsource.sym} -760 390 0 0 {name=Vvssa value=0
format="@name @pinlist @value"}
C {devices/gnd.sym} -760 440 0 0 {name=l1 lab=GND}
C {devices/lab_wire.sym} -760 340 3 1 {name=p6 sig_type=std_logic lab=vssa

}
C {devices/code.sym} -60 390 0 0 {name=STIM_FILE only_toplevel=false value="** opencircuitdesign pdks install
** STD CORNERS **
.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerMOSlv.lib mos_tt
.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerMOShv.lib mos_tt
.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerRES.lib res_typ
*.include /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_stdcell/spice/sg13g2_stdcell.spice
* SG13G2 STD CELLS
*.include /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_stdcell/spice/sg13g2_stdcell.spice
* SG13CMOS5L STD CELLS
.include /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13cmos5l/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice

** MC CORNERS **
*.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerMOShv.lib mos_tt_mismatch
*.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerMOShv.lib mos_ss_mismatch
*.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerMOShv.lib mos_ff_mismatch
*.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerRES.lib res_typ_mismatch
*.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerRES.lib res_bcs_mismatch
*.lib /home/slice/pdk/iHP/IHP-Open-PDK/ihp-sg13g2/libs.tech/ngspice/models/cornerRES.lib res_wcs_mismatch


* Parameters
.param xvdda_hv = 3.3
.csparam xvdda_hv_var = 'xvdda_hv'
.param xvdda_lv = 1.5
.csparam xvdda_lv_var = 'xvdda_lv'
.param cor_id = 0
.csparam cor_id_var = 'cor_id'
.param dec_code_var = 1
.csparam xdec_code_var = 'dec_code_var'
.param xvdda = 3.3
.param xvcm = 3.3/2 
.param xvnbias = 760m
.param xvncasc = 1.184
.param xvpcasc = 2.035
.param xnoise_on = 1
.param xvinp = 10m
.param xvload = 0.7
.param xR1var = 100k
.param xR2var = 50k
.param xRz = 2273
.param xtsim = 1u
.csparam xtsim_var = 'xtsim'
.param xAv = 5
.csparam xAv_var = 'xAv'
.param xstep_en = 1 
.param xint_bias_en = 0
* active lo => 0 = pd
.param xpdb = 1
.param xibias = 5u
.param xCl = 25p
.param xCc = 80p
.param xCz = 3.2p*0
.param xstep = 10m
.param xtstep = 10n
.csparam xtstep_var = 'xtstep'
.param xtrf = 20p
.param xvos = 0m
.param xgmdp = 1m
.param xAv0_dB = 60
.param xGBW = 1Meg

.temp 27

* vlogA instantiation
.model OTA_vcvs OTA_vcvs
.model dec2bin_10b dec2bin_10b
.model ideal_sw ideal_sw
  
.include tb_sunrise_bias_nia_top_CMR_OS.save
  
*.save all

.save v(vout) i(vvdda_hv_opamp)
  
.control

pre_osdi OTA_vcvs.osdi
pre_osdi dec2bin_10b.osdi
pre_osdi ideal_sw.osdi

set xTj = ( 27 )
let xTj_var  = $xTj
set temp = $xTj 

   let run = 1

  dowhile run <= 1
  reset
   
** 1. DCOP ANALYSIS ** 
  
  op 
  remzerovec
  set filetype=binary
  ** first write deletes existing file
  *comment out when running across MC
  write tb_sunrise_opamp_dcop.raw
 
** 2. TRAN ANALYSIS ** 

  remzerovec
  *set appendwrite
  tran $&xtstep_var $&xtsim_var
  *comment out when running across MC
  write tb_sunrise_opamp_tran.raw
  *unset appendwrite 
 
** 3. TRAN MEASURES ** 
 
  * 3.0 Global parameters:   
  echo cor_id = \\"$&cor_id_var\\"
  *comment out when running across MC
  echo \\"$&cor_id_var\\" > vout_v.txt
  echo \\"$&cor_id_var\\" > iddahv_uA.txt
  echo --
  echo temp = \\"$&xTj_var\\"
  *comment out when running across MC
  echo \\"$&xTj_var\\" >> vout_v.txt
  echo \\"$&xTj_var\\" >> iddahv_uA.txt
  echo --  
  echo vdda_hv = \\"$&xvdda_hv_var\\"
  *comment out when running across MC
  echo \\"$&xvdda_hv_var\\" >> vout_v.txt
  echo \\"$&xvdda_hv_var\\" >> iddahv_uA.txt
  echo --
  echo vdda_lv = \\"$&xvdda_lv_var\\"
  *comment out when running across MC
  echo \\"$&xvdda_lv_var\\" >> vout_v.txt
  echo \\"$&xvdda_lv_var\\" >> iddahv_uA.txt
  echo -- 
 
  echo --
  meas tran vout_ave AVG v(vout) from=100n to=$&xtsim_var
  meas tran iddahv_ave AVG i(vvdda_hv_opamp) from=100n to=$&xtsim_var
  let iddahv_ave_uA = iddahv_ave*(-1e6)
  echo --
  echo  vout_V = \\"$&vout_ave\\"
  *comment out when running across MC
  echo  iddahv_A = \\"$&iddahv_ave\\"
  print iddahv_ave_uA
  echo \\"$&vout_ave\\" >> vout_v.txt
  echo \\"$&iddahv_ave_uA\\" >> iddahv_uA.txt
  echo --
 
** 4. AC ANALYSIS ** 
 
  ac dec 10 1 1G
  
  *remzerovec 
  *write tb_sunrise_ina_ac.raw
  
** 5. CMR MEASURES ** 

  * 5.0 Global parameters:   
  echo cor_id = \\"$&cor_id_var\\"
  echo \\"$&cor_id_var\\" > CMRR_DC_dB.txt
  echo --
  echo temp = \\"$&xTj_var\\"
  echo \\"$&xTj_var\\" >> CMRR_DC_dB.txt
  echo --  
  echo vdda_hv = \\"$&xvdda_hv_var\\"
  echo \\"$&xvdda_hv_var\\" >> CMRR_DC_dB.txt
  echo --
  echo vdda_lv = \\"$&xvdda_lv_var\\"
  echo \\"$&xvdda_lv_var\\" >> CMRR_DC_dB.txt
  echo -- 
  
  * 5.1 CMRR:    
  meas AC CMRR_DC_dB FIND vdb(vout) AT=1
  echo --
  echo  CMRR_DC_dB = \\"$&CMRR_DC_dB\\"
  echo \\"$&CMRR_DC_dB\\" >> CMRR_DC_dB.txt
  echo --
  
  remzerovec
  set filetype=binary
  ** first write deletes existing file
  *comment out when running across MC
  write tb_sunrise_opamp_ac.raw
  *typically comment out
  *write tb_sunrise_ina_ac_mc.raw
  ** set appendwrite appends following writes to existing raw file
  set appendwrite
  let run = run+1
  end
 
  setplot
*quit 0
.endc


"}
C {launcher.sym} 580 180 0 0 {name=h1
descr="load_TRAN_waveforms" 
tclcommand="xschem raw_read $netlist_dir/tb_sunrise_opamp_tran.raw tran"


}
C {launcher.sym} 1360 180 0 0 {name=h3
descr="load_CMR_waveforms" 
tclcommand="xschem raw_read $netlist_dir/tb_sunrise_opamp_ac.raw ac"


}
C {devices/capa.sym} 40 1130 0 0 {name=C1
m=1
value=\{xCl\}
footprint=1206
device="ceramic capacitor"}
C {devices/vsource.sym} -560 390 0 0 {name=Vvdda_hv value="xvdda_hv"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -560 440 1 1 {name=p10 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -560 350 1 0 {name=p11 sig_type=std_logic lab=vdda_hv

}
C {devices/vsource.sym} -460 390 0 0 {name=Vnbias value="xvnbias"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -460 440 1 1 {name=p12 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -460 350 1 0 {name=p13 sig_type=std_logic lab=vnbias

}
C {devices/vsource.sym} -360 390 0 0 {name=Vncasc value="xvncasc"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -360 440 1 1 {name=Vncasc1 sig_type=std_logic lab=vssa

value="xvncasc"}
C {devices/vsource.sym} -260 390 0 0 {name=Vpcasc value="xvpcasc"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -260 440 1 1 {name=Vpcasc1 sig_type=std_logic lab=vssa

value="xvpcasc"}
C {devices/lab_wire.sym} -360 350 1 0 {name=p14 sig_type=std_logic lab=vncasc

}
C {devices/lab_wire.sym} -260 350 1 0 {name=p15 sig_type=std_logic lab=vpcasc

}
C {devices/lab_wire.sym} -590 1320 0 1 {name=p16 sig_type=std_logic lab=vcm

}
C {devices/vsource.sym} -160 390 0 0 {name=Vvdda value="xvdda_lv"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -160 440 1 1 {name=p17 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -160 340 1 0 {name=p18 sig_type=std_logic lab=vdda_lv

}
C {devices/launcher.sym} -740 240 0 0 {name=h2
descr=load_DCOP
tclcommand="xschem annotate_op $\{netlist_dir\}/tb_sunrise_opamp_dcop.raw"
}
C {devices/vsource.sym} -660 390 0 0 {name=Vvcm value="xvcm"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -660 440 1 1 {name=p19 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -660 350 1 0 {name=p20 sig_type=std_logic lab=vcm

}
C {devices/lab_wire.sym} -710 700 0 1 {name=p7 sig_type=std_logic lab=vinp

}
C {devices/noconn.sym} -260 330 1 0 {name=l3}
C {devices/noconn.sym} -360 330 1 0 {name=l4}
C {devices/noconn.sym} -460 330 1 0 {name=l5}
C {devices/launcher.sym} -740 20 0 0 {# Process (w. Res) corner sweep for tt, ff, ss, sf, fs
# Assumes stim file has set corner to tt
name=h13
descr="Process (w. Res) / Voltage / Temp corner group (CMRR)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_nia_CMR_OS.spice
xschem netlist
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
################## change to n40 corner ################################
exec sed -i \{s/set xTj = ( 27 )/set xTj = ( -40 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.3/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.5/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_typ/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/tt/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_tt/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_tt/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac.raw/tb_sunrise_opamp_ac_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB.txt/CMRR_DC_dB_ff_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_bcs_vdda_min_n40.txt/CMRR_DC_dB_ss_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/2/3/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_bcs_vdda_min_n40.txt/CMRR_DC_dB_sf_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/3/4/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_bcs_vdda_min_n40.txt/CMRR_DC_dB_fs_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/4/5/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_bcs_vdda_min_n40.txt/CMRR_DC_dB_ff_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/5/6/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_wcs_vdda_min_n40.txt/CMRR_DC_dB_ss_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/6/7/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_wcs_vdda_min_n40.txt/CMRR_DC_dB_sf_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/7/8/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_wcs_vdda_min_n40.txt/CMRR_DC_dB_fs_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/8/9/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_wcs_vdda_min_n40.txt/CMRR_DC_dB_ff_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/9/10/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_bcs_vdda_max_n40.txt/CMRR_DC_dB_ss_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/10/11/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_bcs_vdda_max_n40.txt/CMRR_DC_dB_sf_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/11/12/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_bcs_vdda_max_n40.txt/CMRR_DC_dB_fs_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/12/13/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_bcs_vdda_max_n40.txt/CMRR_DC_dB_ff_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/13/14/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_wcs_vdda_max_n40.txt/CMRR_DC_dB_ss_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/14/15/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_wcs_vdda_max_n40.txt/CMRR_DC_dB_sf_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/15/16/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_wcs_vdda_max_n40.txt/CMRR_DC_dB_fs_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
################## change to 125 corner ################################
exec sed -i \{s/set xTj = ( -40 )/set xTj = ( 125 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.465/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.575/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/16/17/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_wcs_vdda_max_n40.txt/CMRR_DC_dB_ff_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/17/18/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_bcs_vdda_min_125.txt/CMRR_DC_dB_ss_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/18/19/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_bcs_vdda_min_125.txt/CMRR_DC_dB_sf_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/19/20/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_bcs_vdda_min_125.txt/CMRR_DC_dB_fs_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/20/21/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_bcs_vdda_min_125.txt/CMRR_DC_dB_ff_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/21/22/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_wcs_vdda_min_125.txt/CMRR_DC_dB_ss_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/22/23/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_wcs_vdda_min_125.txt/CMRR_DC_dB_sf_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/23/24/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_wcs_vdda_min_125.txt/CMRR_DC_dB_fs_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/24/25/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_wcs_vdda_min_125.txt/CMRR_DC_dB_ff_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/25/26/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_bcs_vdda_max_125.txt/CMRR_DC_dB_ss_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/26/27/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_bcs_vdda_max_125.txt/CMRR_DC_dB_sf_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/27/28/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_bcs_vdda_max_125.txt/CMRR_DC_dB_fs_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/28/29/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_bcs_vdda_max_125.txt/CMRR_DC_dB_ff_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/29/30/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_wcs_vdda_max_125.txt/CMRR_DC_dB_ss_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/30/31/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_wcs_vdda_max_125.txt/CMRR_DC_dB_sf_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/31/32/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_wcs_vdda_max_125.txt/CMRR_DC_dB_fs_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
"

















}
C {devices/launcher.sym} -740 60 0 0 {# Process (w. Res) corner sweep for tt, ff, ss, sf, fs
# Assumes stim file has set corner to tt
name=h4
descr="Process (w. Res) / Voltage / Temp corner group (OS)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_nia_CMR_OS.spice
xschem netlist
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
################## change to n40 corner ################################
exec sed -i \{s/set xTj = ( 27 )/set xTj = ( -40 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.3/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.5/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_typ/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/tt/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_tt/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_tt/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/vout_v.txt/vout_v_ff_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_ff_res_bcs_vdda_min_n40.txt/vout_v_ss_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/2/3/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_ss_res_bcs_vdda_min_n40.txt/vout_v_sf_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/3/4/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_sf_res_bcs_vdda_min_n40.txt/vout_v_fs_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/4/5/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_fs_res_bcs_vdda_min_n40.txt/vout_v_ff_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/5/6/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_ff_res_wcs_vdda_min_n40.txt/vout_v_ss_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/6/7/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_ss_res_wcs_vdda_min_n40.txt/vout_v_sf_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/7/8/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_sf_res_wcs_vdda_min_n40.txt/vout_v_fs_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/8/9/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_fs_res_wcs_vdda_min_n40.txt/vout_v_ff_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/9/10/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_ff_res_bcs_vdda_max_n40.txt/vout_v_ss_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/10/11/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_ss_res_bcs_vdda_max_n40.txt/vout_v_sf_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/11/12/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_sf_res_bcs_vdda_max_n40.txt/vout_v_fs_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/12/13/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_fs_res_bcs_vdda_max_n40.txt/vout_v_ff_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/13/14/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_ff_res_wcs_vdda_max_n40.txt/vout_v_ss_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/14/15/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_ss_res_wcs_vdda_max_n40.txt/vout_v_sf_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/15/16/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/vout_v_sf_res_wcs_vdda_max_n40.txt/vout_v_fs_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
################## change to 125 corner ################################
exec sed -i \{s/set xTj = ( -40 )/set xTj = ( 125 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.465/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.575/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/16/17/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/vout_v_fs_res_wcs_vdda_max_n40.txt/vout_v_ff_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/17/18/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/vout_v_ff_res_bcs_vdda_min_125.txt/vout_v_ss_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/18/19/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/vout_v_ss_res_bcs_vdda_min_125.txt/vout_v_sf_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/19/20/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/vout_v_sf_res_bcs_vdda_min_125.txt/vout_v_fs_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/20/21/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/vout_v_fs_res_bcs_vdda_min_125.txt/vout_v_ff_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/21/22/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/vout_v_ff_res_wcs_vdda_min_125.txt/vout_v_ss_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/22/23/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/vout_v_ss_res_wcs_vdda_min_125.txt/vout_v_sf_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/23/24/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/vout_v_sf_res_wcs_vdda_min_125.txt/vout_v_fs_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/24/25/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/vout_v_fs_res_wcs_vdda_min_125.txt/vout_v_ff_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/25/26/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/vout_v_ff_res_bcs_vdda_max_125.txt/vout_v_ss_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/26/27/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/vout_v_ss_res_bcs_vdda_max_125.txt/vout_v_sf_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/27/28/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/vout_v_sf_res_bcs_vdda_max_125.txt/vout_v_fs_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/28/29/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/vout_v_fs_res_bcs_vdda_max_125.txt/vout_v_ff_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/29/30/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/vout_v_ff_res_wcs_vdda_max_125.txt/vout_v_ss_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/30/31/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/vout_v_ss_res_wcs_vdda_max_125.txt/vout_v_sf_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/31/32/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/vout_v_sf_res_wcs_vdda_max_125.txt/vout_v_fs_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
"

















}
C {devices/launcher.sym} -740 100 0 0 {# Process (w. Res) corner sweep for tt, ff, ss, sf, fs
# Assumes stim file has set corner to tt
name=h5
descr="Process (w. Res) / Voltage / Temp corner group (idda_hv)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_nia_CMR_OS.spice
xschem netlist
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
################## change to n40 corner ################################
exec sed -i \{s/set xTj = ( 27 )/set xTj = ( -40 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.3/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.5/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_typ/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/tt/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_tt/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_tt/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA.txt/iddahv_uA_ff_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_bcs_vdda_min_n40.txt/iddahv_uA_ss_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/2/3/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_bcs_vdda_min_n40.txt/iddahv_uA_sf_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/3/4/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_bcs_vdda_min_n40.txt/iddahv_uA_fs_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/4/5/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_bcs_vdda_min_n40.txt/iddahv_uA_ff_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/5/6/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_wcs_vdda_min_n40.txt/iddahv_uA_ss_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/6/7/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_wcs_vdda_min_n40.txt/iddahv_uA_sf_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/7/8/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_wcs_vdda_min_n40.txt/iddahv_uA_fs_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/8/9/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_wcs_vdda_min_n40.txt/iddahv_uA_ff_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/9/10/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_bcs_vdda_max_n40.txt/iddahv_uA_ss_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/10/11/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_bcs_vdda_max_n40.txt/iddahv_uA_sf_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/11/12/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_bcs_vdda_max_n40.txt/iddahv_uA_fs_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/12/13/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_bcs_vdda_max_n40.txt/iddahv_uA_ff_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/13/14/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_wcs_vdda_max_n40.txt/iddahv_uA_ss_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/14/15/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_wcs_vdda_max_n40.txt/iddahv_uA_sf_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/15/16/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_wcs_vdda_max_n40.txt/iddahv_uA_fs_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
################## change to 125 corner ################################
exec sed -i \{s/set xTj = ( -40 )/set xTj = ( 125 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.465/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.575/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/16/17/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_wcs_vdda_max_n40.txt/iddahv_uA_ff_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/17/18/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_bcs_vdda_min_125.txt/iddahv_uA_ss_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/18/19/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_bcs_vdda_min_125.txt/iddahv_uA_sf_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/19/20/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_bcs_vdda_min_125.txt/iddahv_uA_fs_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/20/21/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_bcs_vdda_min_125.txt/iddahv_uA_ff_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/21/22/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_wcs_vdda_min_125.txt/iddahv_uA_ss_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/22/23/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_wcs_vdda_min_125.txt/iddahv_uA_sf_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/23/24/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_wcs_vdda_min_125.txt/iddahv_uA_fs_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/24/25/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_wcs_vdda_min_125.txt/iddahv_uA_ff_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/25/26/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_bcs_vdda_max_125.txt/iddahv_uA_ss_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/26/27/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_bcs_vdda_max_125.txt/iddahv_uA_sf_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/27/28/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_bcs_vdda_max_125.txt/iddahv_uA_fs_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/28/29/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_bcs_vdda_max_125.txt/iddahv_uA_ff_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/29/30/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_wcs_vdda_max_125.txt/iddahv_uA_ss_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/30/31/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_wcs_vdda_max_125.txt/iddahv_uA_sf_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/31/32/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_tran_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_tran_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_wcs_vdda_max_125.txt/iddahv_uA_fs_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 2000 ;# wait 1sec for ngspice to start and read netlist
"

















}
C {sunrise/dec2bin_10b.sym} 1370 900 0 0 {name=xidec2bin
xschematic=dec2bin_10b.sch
model=dec2bin_10b
dec_code = dec_code_var}
C {devices/lab_pin.sym} 1560 810 2 0 {name=p47 sig_type=std_logic lab=bin_out_9}
C {devices/lab_pin.sym} 1560 830 2 0 {name=p48 sig_type=std_logic lab=bin_out_8}
C {devices/lab_pin.sym} 1560 850 2 0 {name=p49 sig_type=std_logic lab=bin_out_7}
C {devices/lab_pin.sym} 1560 870 2 0 {name=p50 sig_type=std_logic lab=bin_out_6}
C {devices/lab_pin.sym} 1560 890 2 0 {name=p51 sig_type=std_logic lab=bin_out_5}
C {devices/lab_pin.sym} 1560 910 2 0 {name=p52 sig_type=std_logic lab=bin_out_4}
C {devices/lab_pin.sym} 1560 930 2 0 {name=p53 sig_type=std_logic lab=bin_out_3}
C {devices/lab_pin.sym} 1560 950 2 0 {name=p54 sig_type=std_logic lab=bin_out_2}
C {devices/lab_pin.sym} 1560 970 2 0 {name=p55 sig_type=std_logic lab=rdac_ctrl_1}
C {devices/lab_pin.sym} 1560 990 2 0 {name=p56 sig_type=std_logic lab=rdac_ctrl_0}
C {noconn.sym} 1560 810 1 0 {name=l6}
C {noconn.sym} 1560 830 1 0 {name=l7}
C {noconn.sym} 1560 850 1 0 {name=l8}
C {noconn.sym} 1560 870 1 0 {name=l9}
C {noconn.sym} 1560 890 1 0 {name=l10}
C {noconn.sym} 1560 910 1 0 {name=l11}
C {noconn.sym} 1560 930 1 0 {name=l12}
C {noconn.sym} 1560 950 1 0 {name=l13}
C {devices/lab_wire.sym} 1200 830 0 0 {name=p45 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} 1200 810 0 0 {name=p46 sig_type=std_logic lab=vdda_lv

}
C {devices/launcher.sym} -740 140 0 0 {# Process (w. Res) corner sweep for tt, ff, ss, sf, fs
# Assumes stim file has set corner to tt
name=h6
descr="Process (w. Res) / Voltage / Temp corner group (CMRR/OS/idda_hv)"
tclcommand="
set spicefile $netlist_dir/tb_sunrise_opamp_bias_nia_CMR_OS.spice
xschem netlist
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
################## change to n40 corner ################################
exec sed -i \{s/set xTj = ( 27 )/set xTj = ( -40 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.3/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.5/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_typ/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/0/1/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/tt/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_tt/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_tt/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac.raw/tb_sunrise_opamp_ac_ff_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB.txt/CMRR_DC_dB_ff_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/vout_v.txt/vout_v_ff_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA.txt/iddahv_uA_ff_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/1/2/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_ss_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_bcs_vdda_min_n40.txt/CMRR_DC_dB_ss_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_ff_res_bcs_vdda_min_n40.txt/vout_v_ss_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_bcs_vdda_min_n40.txt/iddahv_uA_ss_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/2/3/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_sf_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_bcs_vdda_min_n40.txt/CMRR_DC_dB_sf_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_ss_res_bcs_vdda_min_n40.txt/vout_v_sf_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_bcs_vdda_min_n40.txt/iddahv_uA_sf_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/3/4/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_fs_res_bcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_bcs_vdda_min_n40.txt/CMRR_DC_dB_fs_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_sf_res_bcs_vdda_min_n40.txt/vout_v_fs_res_bcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_bcs_vdda_min_n40.txt/iddahv_uA_fs_res_bcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/4/5/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_bcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_ff_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_bcs_vdda_min_n40.txt/CMRR_DC_dB_ff_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_fs_res_bcs_vdda_min_n40.txt/vout_v_ff_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_bcs_vdda_min_n40.txt/iddahv_uA_ff_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/5/6/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_ss_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_wcs_vdda_min_n40.txt/CMRR_DC_dB_ss_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_ff_res_wcs_vdda_min_n40.txt/vout_v_ss_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_wcs_vdda_min_n40.txt/iddahv_uA_ss_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/6/7/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_sf_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_wcs_vdda_min_n40.txt/CMRR_DC_dB_sf_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_ss_res_wcs_vdda_min_n40.txt/vout_v_sf_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_wcs_vdda_min_n40.txt/iddahv_uA_sf_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/7/8/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_fs_res_wcs_vdda_min_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_wcs_vdda_min_n40.txt/CMRR_DC_dB_fs_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_sf_res_wcs_vdda_min_n40.txt/vout_v_fs_res_wcs_vdda_min_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_wcs_vdda_min_n40.txt/iddahv_uA_fs_res_wcs_vdda_min_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/8/9/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_wcs_vdda_min_n40.raw/tb_sunrise_opamp_ac_ff_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_wcs_vdda_min_n40.txt/CMRR_DC_dB_ff_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_fs_res_wcs_vdda_min_n40.txt/vout_v_ff_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_wcs_vdda_min_n40.txt/iddahv_uA_ff_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/9/10/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_ss_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_bcs_vdda_max_n40.txt/CMRR_DC_dB_ss_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_ff_res_bcs_vdda_max_n40.txt/vout_v_ss_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_bcs_vdda_max_n40.txt/iddahv_uA_ss_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/10/11/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_sf_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_bcs_vdda_max_n40.txt/CMRR_DC_dB_sf_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_ss_res_bcs_vdda_max_n40.txt/vout_v_sf_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_bcs_vdda_max_n40.txt/iddahv_uA_sf_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/11/12/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_fs_res_bcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_bcs_vdda_max_n40.txt/CMRR_DC_dB_fs_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_sf_res_bcs_vdda_max_n40.txt/vout_v_fs_res_bcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_bcs_vdda_max_n40.txt/iddahv_uA_fs_res_bcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/12/13/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_bcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_ff_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_bcs_vdda_max_n40.txt/CMRR_DC_dB_ff_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_fs_res_bcs_vdda_max_n40.txt/vout_v_ff_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_bcs_vdda_max_n40.txt/iddahv_uA_ff_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/13/14/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_ss_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_wcs_vdda_max_n40.txt/CMRR_DC_dB_ss_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_ff_res_wcs_vdda_max_n40.txt/vout_v_ss_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_wcs_vdda_max_n40.txt/iddahv_uA_ss_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/14/15/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_sf_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_wcs_vdda_max_n40.txt/CMRR_DC_dB_sf_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_ss_res_wcs_vdda_max_n40.txt/vout_v_sf_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_wcs_vdda_max_n40.txt/iddahv_uA_sf_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/15/16/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_fs_res_wcs_vdda_max_n40.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_wcs_vdda_max_n40.txt/CMRR_DC_dB_fs_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/vout_v_sf_res_wcs_vdda_max_n40.txt/vout_v_fs_res_wcs_vdda_max_n40.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_wcs_vdda_max_n40.txt/iddahv_uA_fs_res_wcs_vdda_max_n40.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
################## change to 125 corner ################################
exec sed -i \{s/set xTj = ( -40 )/set xTj = ( 125 )/\} $spicefile
##################  set vdda = vdda_min ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.465/3.135/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.575/1.425/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/16/17/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_wcs_vdda_max_n40.raw/tb_sunrise_opamp_ac_ff_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_wcs_vdda_max_n40.txt/CMRR_DC_dB_ff_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/vout_v_fs_res_wcs_vdda_max_n40.txt/vout_v_ff_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_wcs_vdda_max_n40.txt/iddahv_uA_ff_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/17/18/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac_ss_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_bcs_vdda_min_125.txt/CMRR_DC_dB_ss_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/vout_v_ff_res_bcs_vdda_min_125.txt/vout_v_ss_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_bcs_vdda_min_125.txt/iddahv_uA_ss_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/18/19/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac_sf_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_bcs_vdda_min_125.txt/CMRR_DC_dB_sf_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/vout_v_ss_res_bcs_vdda_min_125.txt/vout_v_sf_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_bcs_vdda_min_125.txt/iddahv_uA_sf_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/19/20/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac_fs_res_bcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_bcs_vdda_min_125.txt/CMRR_DC_dB_fs_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/vout_v_sf_res_bcs_vdda_min_125.txt/vout_v_fs_res_bcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_bcs_vdda_min_125.txt/iddahv_uA_fs_res_bcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/20/21/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_bcs_vdda_min_125.raw/tb_sunrise_opamp_ac_ff_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_bcs_vdda_min_125.txt/CMRR_DC_dB_ff_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/vout_v_fs_res_bcs_vdda_min_125.txt/vout_v_ff_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_bcs_vdda_min_125.txt/iddahv_uA_ff_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/21/22/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac_ss_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_wcs_vdda_min_125.txt/CMRR_DC_dB_ss_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/vout_v_ff_res_wcs_vdda_min_125.txt/vout_v_ss_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_wcs_vdda_min_125.txt/iddahv_uA_ss_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/22/23/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac_sf_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_wcs_vdda_min_125.txt/CMRR_DC_dB_sf_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/vout_v_ss_res_wcs_vdda_min_125.txt/vout_v_sf_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_wcs_vdda_min_125.txt/iddahv_uA_sf_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/23/24/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac_fs_res_wcs_vdda_min_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_wcs_vdda_min_125.txt/CMRR_DC_dB_fs_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/vout_v_sf_res_wcs_vdda_min_125.txt/vout_v_fs_res_wcs_vdda_min_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_wcs_vdda_min_125.txt/iddahv_uA_fs_res_wcs_vdda_min_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
################## set vdda = vdda_max ################################
exec sed -i \{/^\\.param xvdda_hv/s/3.135/3.465/\} $spicefile
exec sed -i \{/^\\.param xvdda_lv/s/1.425/1.575/\} $spicefile
##################  set res = res_bcs ################################
exec sed -i \{s/cornerRES.lib res_wcs/cornerRES.lib res_bcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/24/25/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_wcs_vdda_min_125.raw/tb_sunrise_opamp_ac_ff_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_wcs_vdda_min_125.txt/CMRR_DC_dB_ff_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/vout_v_fs_res_wcs_vdda_min_125.txt/vout_v_ff_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_wcs_vdda_min_125.txt/iddahv_uA_ff_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/25/26/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac_ss_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_bcs_vdda_max_125.txt/CMRR_DC_dB_ss_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/vout_v_ff_res_bcs_vdda_max_125.txt/vout_v_ss_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_bcs_vdda_max_125.txt/iddahv_uA_ss_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/26/27/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac_sf_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_bcs_vdda_max_125.txt/CMRR_DC_dB_sf_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/vout_v_ss_res_bcs_vdda_max_125.txt/vout_v_sf_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_bcs_vdda_max_125.txt/iddahv_uA_sf_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/27/28/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac_fs_res_bcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_bcs_vdda_max_125.txt/CMRR_DC_dB_fs_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/vout_v_sf_res_bcs_vdda_max_125.txt/vout_v_fs_res_bcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_bcs_vdda_max_125.txt/iddahv_uA_fs_res_bcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
##################  set res = res_wcs ################################
exec sed -i \{s/cornerRES.lib res_bcs/cornerRES.lib res_wcs/\} $spicefile
# change to ff corner
exec sed -i \{/^\\.param cor_id/s/28/29/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/fs/ff/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_fs/cornerMOSlv.lib mos_ff/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_fs/cornerMOShv.lib mos_ff/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_fs_res_bcs_vdda_max_125.raw/tb_sunrise_opamp_ac_ff_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_fs_res_bcs_vdda_max_125.txt/CMRR_DC_dB_ff_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/vout_v_fs_res_bcs_vdda_max_125.txt/vout_v_ff_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_fs_res_bcs_vdda_max_125.txt/iddahv_uA_ff_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to ss corner
exec sed -i \{/^\\.param cor_id/s/29/30/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ff/ss/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ff/cornerMOSlv.lib mos_ss/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ff/cornerMOShv.lib mos_ss/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ff_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac_ss_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ff_res_wcs_vdda_max_125.txt/CMRR_DC_dB_ss_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/vout_v_ff_res_wcs_vdda_max_125.txt/vout_v_ss_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ff_res_wcs_vdda_max_125.txt/iddahv_uA_ss_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to sf corner
exec sed -i \{/^\\.param cor_id/s/30/31/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/ss/sf/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_ss/cornerMOSlv.lib mos_sf/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_ss/cornerMOShv.lib mos_sf/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_ss_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac_sf_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_ss_res_wcs_vdda_max_125.txt/CMRR_DC_dB_sf_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/vout_v_ss_res_wcs_vdda_max_125.txt/vout_v_sf_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_ss_res_wcs_vdda_max_125.txt/iddahv_uA_sf_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
# change to fs corner
exec sed -i \{/^\\.param cor_id/s/31/32/\} $spicefile
# use below if you want to change both MOShv and MOSlv corners simultaneously
#exec sed -i \{/^\\.lib/s/sf/fs/\} $spicefile
# use below if you want to change MOSlv corner only
#exec sed -i \{s/cornerMOSlv.lib mos_sf/cornerMOSlv.lib mos_fs/\} $spicefile
# use below if you want to change MOShv corner only
exec sed -i \{s/cornerMOShv.lib mos_sf/cornerMOShv.lib mos_fs/\} $spicefile
exec sed -i \{s/tb_sunrise_opamp_ac_sf_res_wcs_vdda_max_125.raw/tb_sunrise_opamp_ac_fs_res_wcs_vdda_max_125.raw/\} $spicefile
exec sed -i \{s/CMRR_DC_dB_sf_res_wcs_vdda_max_125.txt/CMRR_DC_dB_fs_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/vout_v_sf_res_wcs_vdda_max_125.txt/vout_v_fs_res_wcs_vdda_max_125.txt/\} $spicefile
exec sed -i \{s/iddahv_uA_sf_res_wcs_vdda_max_125.txt/iddahv_uA_fs_res_wcs_vdda_max_125.txt/\} $spicefile
simulate
after 10000 ;# wait 1sec for ngspice to start and read netlist
"

















}
C {lab_wire.sym} -670 1100 0 1 {name=p28 sig_type=std_logic lab=rdac_ctrlb_onehot_hv[2:0]}
C {lab_wire.sym} -660 1080 0 1 {name=p29 sig_type=std_logic lab=rdac_ctrl_onehot_hv[2:0]}
C {sunrise/sunrise_rdac.sym} -340 1080 0 0 {name=xirdac}
C {devices/lab_wire.sym} -340 980 0 0 {name=p35 sig_type=std_logic lab=vdda_hv

}
C {devices/lab_wire.sym} -360 1220 0 0 {name=p27 sig_type=std_logic lab=vssa

}
C {lab_wire.sym} -1810 280 0 1 {name=p4 sig_type=std_logic lab=rdac_ctrl_onehot[2:0]}
C {lab_wire.sym} -1480 340 0 1 {name=p8 sig_type=std_logic lab=rdac_ctrlb_onehot_hv[2:0]}
C {lab_wire.sym} -1690 420 0 1 {name=p9 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -1690 160 0 1 {name=p30 sig_type=std_logic lab=vdda_lv}
C {lab_wire.sym} -1480 200 0 1 {name=p36 sig_type=std_logic lab=rdac_ctrl_onehot_hv[2:0]}
C {sunrise/sunrise_rdac_ctrl.sym} -1930 280 0 0 {name=xirdac_ctrl1}
C {sunrise/lvl_shfters.sym} -1490 400 0 0 {name=xilvl_shft1}
C {devices/lab_wire.sym} -2260 280 0 1 {name=p37 sig_type=std_logic lab=rdac_ctrl_1,rdac_ctrl_0

}
C {lab_wire.sym} -2150 260 0 1 {name=p38 sig_type=std_logic lab=vdda_lv}
C {lab_wire.sym} -2130 300 0 1 {name=p39 sig_type=std_logic lab=vssa}
C {devices/lab_wire.sym} -2070 1320 0 1 {name=p40 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -1730 1080 0 0 {name=p41 sig_type=std_logic lab=vssa

}
C {devices/vsource.sym} -1470 1250 0 0 {name=Vvload1 value="xvload"
format="@name @pinlist @value"}
C {devices/vsource.sym} -1350 1250 0 0 {name=Vvload2 value="xvload"
format="@name @pinlist @value"}
C {lab_wire.sym} -3430 1220 0 1 {name=p42 sig_type=std_logic lab=vssa}
C {sg13g2_pr/sg13_hv_nmos.sym} -3370 1220 0 1 {name=Mnbias_ip_lhs
l=8.28u
w=6u
ng=1
m=4
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} -3050 1220 0 0 {name=p43 sig_type=std_logic lab=vssa}
C {sg13g2_pr/sg13_hv_nmos.sym} -3110 1220 0 0 {name=Mnbias_ip_rhs
l=8.28u
w=6u
ng=1
m=4
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} -3130 660 0 1 {name=p44 sig_type=std_logic lab=vdda_hv}
C {lab_wire.sym} -3130 480 0 1 {name=p57 sig_type=std_logic lab=vdda_hv}
C {sg13g2_pr/sg13_hv_pmos.sym} -3070 660 0 1 {name=Mpcasc_stg1_bias_lhs
l=0.43u
w=7.5u
ng=1
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_pmos.sym} -3070 480 0 1 {name=Mpbias_stg1_bias_lhs
l=4.9u
w=7.5u
ng=1
m=4
model=sg13_hv_pmos
spiceprefix=X
}
C {lab_wire.sym} -2690 660 0 0 {name=p58 sig_type=std_logic lab=vdda_hv}
C {lab_wire.sym} -2690 480 0 0 {name=p59 sig_type=std_logic lab=vdda_hv}
C {sg13g2_pr/sg13_hv_pmos.sym} -2750 660 0 0 {name=Mpcasc_stg1_bias_rhs
l=0.43u
w=7.5u
ng=1
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_pmos.sym} -2750 480 0 0 {name=Mpbias_stg1_bias_rhs
l=4.9u
w=7.5u
ng=1
m=4
model=sg13_hv_pmos
spiceprefix=X
}
C {lab_wire.sym} -3050 920 0 1 {name=p67 sig_type=std_logic lab=vpcasc_in}
C {lab_wire.sym} -3060 740 0 1 {name=p68 sig_type=std_logic lab=vpbias_in}
C {sg13g2_pr/rppd.sym} -3090 830 0 0 {name=R4
w=0.5e-6
l=146.97e-6
model=rppd
body=vssa
spiceprefix=X
b=0
m=1
}
C {lab_wire.sym} -3090 520 1 1 {name=p60 sig_type=std_logic lab=vd_pbias_bias_lhs}
C {lab_wire.sym} -2730 520 1 1 {name=p61 sig_type=std_logic lab=vd_pbias_bias_rhs1}
C {isource.sym} -3390 740 0 0 {name=I2 value="xibias"}
C {devices/lab_wire.sym} -2850 380 0 0 {name=p62 sig_type=std_logic lab=vdda_hv

}
C {devices/lab_wire.sym} -3250 1320 0 1 {name=p64 sig_type=std_logic lab=vssa

}
C {isource.sym} -2050 650 0 0 {name=I3 value="xibias"}
C {devices/vsource.sym} -2710 1250 0 0 {name=Vint_bias value="\{xint_bias_en*xvdda_lv\}"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -2480 1220 0 0 {name=p65 sig_type=std_logic lab=pdb

}
C {devices/lab_wire.sym} -2550 1200 0 0 {name=p66 sig_type=std_logic lab=int_bias

}
C {devices/lab_wire.sym} -2160 1180 0 0 {name=p69 sig_type=std_logic lab=int_bias_int

}
C {devices/lab_wire.sym} -2150 1200 0 0 {name=p70 sig_type=std_logic lab=int_bias_intb

}
C {devices/lab_wire.sym} -2160 1220 0 0 {name=p71 sig_type=std_logic lab=ext_bias_int

}
C {devices/lab_wire.sym} -2150 1240 0 0 {name=p72 sig_type=std_logic lab=ext_bias_intb

}
C {devices/lab_wire.sym} -2390 1100 0 0 {name=p73 sig_type=std_logic lab=vdda_lv

}
C {devices/lab_wire.sym} -1730 1040 0 0 {name=p74 sig_type=std_logic lab=ndio

}
C {lab_wire.sym} -1830 950 1 0 {name=p75 sig_type=std_logic lab=int_bias_int_hv}
C {lab_wire.sym} -1870 960 1 0 {name=p76 sig_type=std_logic lab=int_bias_intb_hv}
C {lab_wire.sym} -1750 950 1 0 {name=p77 sig_type=std_logic lab=ext_bias_int_hv}
C {lab_wire.sym} -1790 960 1 0 {name=p78 sig_type=std_logic lab=ext_bias_intb_hv}
C {ideal_switch.sym} -1970 890 1 0 {name=x2}
C {devices/lab_wire.sym} -2030 800 0 0 {name=p79 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -1950 720 1 0 {name=p80 sig_type=std_logic lab=vdda_hv

}
C {lab_wire.sym} -1770 800 0 0 {name=p81 sig_type=std_logic lab=ext_bias_int_hv}
C {ideal_switch.sym} -2360 1040 0 1 {name=x3}
C {devices/lab_wire.sym} -2190 1020 0 1 {name=p82 sig_type=std_logic lab=vdda_hv

}
C {devices/vsource.sym} -2050 930 0 0 {name=Viin_id value=0
format="@name @pinlist @value"}
C {devices/vsource.sym} -2150 1040 1 0 {name=Viin_mir value=0
format="@name @pinlist @value"}
C {devices/vsource.sym} -1960 1040 3 0 {name=Viin value=0
format="@name @pinlist @value"}
C {lab_wire.sym} -2310 1080 0 1 {name=p83 sig_type=std_logic lab=vssa}
C {devices/lab_wire.sym} -2160 1160 0 0 {name=p84 sig_type=std_logic lab=pdb_int

}
C {devices/lab_wire.sym} -2160 1140 0 0 {name=p85 sig_type=std_logic lab=pd_int

}
C {sg13g2_stdcells/sg13g2_or2_1.sym} -2410 860 1 0 {name=x4 VDD=vdda_hv VSS=vssa prefix=sg13g2_ }
C {lab_wire.sym} -2290 680 3 0 {name=p86 sig_type=std_logic lab=int_bias_int_hv}
C {devices/lab_wire.sym} -2250 730 3 0 {name=p87 sig_type=std_logic lab=pd_int_hv

}
C {lab_wire.sym} -1250 910 1 0 {name=p88 sig_type=std_logic lab=pd_int_hv}
C {lab_wire.sym} -1230 920 1 0 {name=p89 sig_type=std_logic lab=pdb_int_hv}
C {devices/vsource.sym} -2610 1250 0 1 {name=Vstep2 value="pwl (0 0 2u 0 \{2u+xtrf\} xvdda_lv 4u xvdda_lv \{4u+xtrf\} 0)"
format="@name @pinlist @value"
}
C {devices/lab_wire.sym} -1890 560 0 0 {name=p90 sig_type=std_logic lab=vdda_hv

}
C {devices/vsource.sym} -2530 1270 0 0 {name=Vpdb1 value="\{xpdb*xvdda_lv\}"
format="@name @pinlist @value"}
C {noconn.sym} -2530 1240 0 0 {name=l14}
C {noconn.sym} -2610 1220 0 0 {name=l15}
C {sunrise/sunrise_logic_pd_bias.sym} -2390 1280 0 0 {name=x5}
C {sunrise/sunrise_bias.sym} -1530 1040 0 0 {name=xibias}
C {vcvs.sym} -2510 -100 0 0 {name=E4 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -2580 -80 0 0 {name=p91 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -2570 -120 0 0 {name=p92 sig_type=std_logic lab=int_bias_int}
C {lab_wire.sym} -2510 -160 1 0 {name=p93 sig_type=std_logic lab=int_bias_int_hv}
C {lab_wire.sym} -2510 20 1 0 {name=p94 sig_type=std_logic lab=vssa}
C {vcvs.sym} -2170 -100 0 0 {name=E1 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -2240 -80 0 0 {name=p95 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -2230 -120 0 0 {name=p96 sig_type=std_logic lab=int_bias_intb}
C {lab_wire.sym} -2170 -160 1 0 {name=p97 sig_type=std_logic lab=int_bias_intb_hv}
C {lab_wire.sym} -2170 20 1 0 {name=p98 sig_type=std_logic lab=vssa}
C {vcvs.sym} -1810 -100 0 0 {name=E2 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -1880 -80 0 0 {name=p99 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -1870 -120 0 0 {name=p100 sig_type=std_logic lab=ext_bias_int}
C {lab_wire.sym} -1810 -160 1 0 {name=p101 sig_type=std_logic lab=ext_bias_int_hv}
C {lab_wire.sym} -1810 20 1 0 {name=p102 sig_type=std_logic lab=vssa}
C {vcvs.sym} -1470 -100 0 0 {name=E3 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -1540 -80 0 0 {name=p103 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -1530 -120 0 0 {name=p104 sig_type=std_logic lab=ext_bias_intb}
C {lab_wire.sym} -1470 -160 1 0 {name=p105 sig_type=std_logic lab=ext_bias_intb_hv}
C {lab_wire.sym} -1470 20 1 0 {name=p106 sig_type=std_logic lab=vssa}
C {vcvs.sym} -3250 -100 0 0 {name=E5 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -3320 -80 0 0 {name=p107 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -3310 -120 0 0 {name=p108 sig_type=std_logic lab=pdb_int}
C {lab_wire.sym} -3250 -160 1 0 {name=p109 sig_type=std_logic lab=pdb_int_hv}
C {lab_wire.sym} -3250 20 1 0 {name=p110 sig_type=std_logic lab=vssa}
C {vcvs.sym} -2910 -100 0 0 {name=E6 value=\{xvdda_hv/xvdda_lv\}}
C {lab_wire.sym} -2980 -80 0 0 {name=p111 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -2970 -120 0 0 {name=p112 sig_type=std_logic lab=pd_int}
C {lab_wire.sym} -2910 -160 1 0 {name=p113 sig_type=std_logic lab=pd_int_hv}
C {lab_wire.sym} -2910 20 1 0 {name=p114 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -1590 1300 1 0 {name=p115 sig_type=std_logic lab=ibias_in_5u}
C {devices/vsource.sym} -1590 1170 0 0 {name=Viprb_bias_ value=0
format="@name @pinlist @value"}
C {devices/vsource.sym} -1040 380 0 0 {name=Vvdda_hv_opamp value="xvdda_hv"
format="@name @pinlist @value"}
C {devices/lab_wire.sym} -1040 430 1 1 {name=p21 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -1040 340 1 0 {name=p22 sig_type=std_logic lab=vdda_hv_opamp

}
C {sunrise/sunrise_NIA_loop_top.sym} -320 880 0 0 {name=xnia}
C {lab_wire.sym} -510 680 0 0 {name=p24 sig_type=std_logic lab=ibias_in_5u}
C {lab_wire.sym} -500 760 0 0 {name=p25 sig_type=std_logic lab=pd_int_hv}
C {lab_wire.sym} -500 780 0 0 {name=p26 sig_type=std_logic lab=pdb_int_hv}
C {devices/lab_wire.sym} -340 920 0 1 {name=p32 sig_type=std_logic lab=vssa

}
C {devices/lab_wire.sym} -380 580 0 0 {name=p33 sig_type=std_logic lab=vdda_hv_opamp

}
C {devices/lab_wire.sym} -60 720 0 1 {name=p1 sig_type=std_logic lab=vout

}
C {sg13cmos5l_stdcells/sg13cmos5l_or2_1.sym} -2270 880 1 0 {name=x1 VDD=vdda_hv VSS=vssa prefix=sg13cmos5l_ }
