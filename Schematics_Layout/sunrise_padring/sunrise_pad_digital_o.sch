v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -50 200 -20 200 {lab=c2p}
N -140 200 -110 200 {lab=pad}
C {iopin.sym} -140 0 2 0 {name=p3 lab=iovss}
C {iopin.sym} -140 -40 2 0 {name=p4 lab=iovdd}
C {iopin.sym} -140 120 2 0 {name=p5 lab=vdd}
C {iopin.sym} -140 160 2 0 {name=p6 lab=vss}
C {iopin.sym} -20 200 0 0 {name=p8 lab=c2p}
C {iopin.sym} -140 200 2 0 {name=p2 lab=pad}
C {iopin.sym} -140 -80 2 0 {name=p7 lab=iovdd_uq0}
C {iopin.sym} -140 40 2 0 {name=p10 lab=iovss_uq0}
C {vsource.sym} -80 200 1 0 {name=V1 value=0 savecurrent=false}
