v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {iopin.sym} 20 -20 2 0 {name=p3 lab=iovss}
C {iopin.sym} 20 -60 2 0 {name=p4 lab=iovdd_uq0}
C {iopin.sym} 20 140 2 0 {name=p5 lab=vdd}
C {iopin.sym} 20 180 2 0 {name=p1 lab=vss}
C {iopin.sym} 20 20 2 0 {name=p2 lab=iovss_uq0}
C {iopin.sym} 20 60 2 0 {name=p6 lab=iovss_uq1}
C {iopin.sym} 20 100 2 0 {name=p7 lab=iovss_uq2}
C {iopin.sym} 20 -100 2 0 {name=p8 lab=iovdd}
