v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -40 200 -20 200 {lab=p2c}
N -140 200 -100 200 {lab=pad}
C {iopin.sym} -20 200 0 0 {name=p1 lab=p2c}
C {iopin.sym} -140 0 2 0 {name=p3 lab=iovss}
C {iopin.sym} -140 -40 2 0 {name=p4 lab=iovdd_uq0}
C {iopin.sym} -140 120 2 0 {name=p5 lab=vdd}
C {iopin.sym} -140 160 2 0 {name=p6 lab=vss}
C {iopin.sym} -140 200 2 0 {name=p2 lab=pad}
C {iopin.sym} -140 -80 2 0 {name=p7 lab=iovdd}
C {iopin.sym} -140 40 2 0 {name=p8 lab=iovss_uq1}
C {iopin.sym} -140 80 2 0 {name=p9 lab=iovss_uq0}
C {vsource.sym} -70 200 1 0 {name=V1 value=0 savecurrent=false}
