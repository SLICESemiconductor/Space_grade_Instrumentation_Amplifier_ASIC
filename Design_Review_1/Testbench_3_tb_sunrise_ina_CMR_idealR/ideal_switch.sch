v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {N1 cn cp n p vdd ideal_sw}
E {}
C {devices/ipin.sym} -20 -40 0 0 {name=p1 lab=vdd}
C {devices/ipin.sym} -20 -20 0 0 {name=p2 lab=cp}
C {devices/ipin.sym} -20 0 0 0 {name=p3 lab=cn}
C {devices/iopin.sym} 40 -20 0 0 {name=p4 lab=p
}
C {devices/iopin.sym} 40 0 0 0 {name=p5 lab=n}
C {noconn.sym} 40 -20 0 0 {name=l1}
C {noconn.sym} 40 0 0 0 {name=l2}
C {noconn.sym} -20 -40 2 0 {name=l3}
C {noconn.sym} -20 -20 2 0 {name=l4}
C {noconn.sym} -20 0 2 0 {name=l5}
